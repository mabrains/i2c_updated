* NGSPICE file created from i2c_master_top.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_2 abstract view
.subckt sky130_fd_sc_hd__and4b_2 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_2 abstract view
.subckt sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

.subckt i2c_master_top arst_i scl_pad_i scl_pad_o scl_padoen_o sda_pad_i sda_pad_o
+ sda_padoen_o wb_ack_o wb_adr_i[0] wb_adr_i[1] wb_adr_i[2] wb_clk_i wb_cyc_i wb_dat_i[0]
+ wb_dat_i[1] wb_dat_i[2] wb_dat_i[3] wb_dat_i[4] wb_dat_i[5] wb_dat_i[6] wb_dat_i[7]
+ wb_dat_o[0] wb_dat_o[1] wb_dat_o[2] wb_dat_o[3] wb_dat_o[4] wb_dat_o[5] wb_dat_o[6]
+ wb_dat_o[7] wb_inta_o wb_rst_i wb_stb_i wb_we_i VPWR VGND
XFILLER_54_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2037_ _2121_/D VGND VGND VPWR VPWR _2037_/Y sky130_fd_sc_hd__inv_2
X_2106_ _2234_/Q _2220_/Q _2186_/Q VGND VGND VPWR VPWR _2106_/X sky130_fd_sc_hd__mux2_1
XFILLER_52_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1270_ _1270_/A VGND VGND VPWR VPWR _1270_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_36_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1606_ _1807_/C VGND VGND VPWR VPWR _1620_/A sky130_fd_sc_hd__clkbuf_2
X_1468_ _1471_/A VGND VGND VPWR VPWR _1468_/X sky130_fd_sc_hd__clkbuf_1
X_1537_ _1539_/A VGND VGND VPWR VPWR _1537_/X sky130_fd_sc_hd__clkbuf_1
X_1399_ _1405_/A VGND VGND VPWR VPWR _1399_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_27_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1253_ _1257_/A VGND VGND VPWR VPWR _1253_/X sky130_fd_sc_hd__clkbuf_1
X_1322_ _2252_/Q _1330_/C _1322_/C _1337_/D VGND VGND VPWR VPWR _1332_/A sky130_fd_sc_hd__or4_4
X_1184_ _1248_/A VGND VGND VPWR VPWR _1220_/A sky130_fd_sc_hd__buf_2
XFILLER_23_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1940_ _2275_/Q _1209_/B _1210_/B VGND VGND VPWR VPWR _1940_/X sky130_fd_sc_hd__a21bo_1
XFILLER_14_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1871_ _2212_/Q _2204_/Q _2127_/Q _2188_/Q VGND VGND VPWR VPWR _1871_/X sky130_fd_sc_hd__or4_4
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1236_ _1246_/A VGND VGND VPWR VPWR _1236_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_56_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1305_ _1355_/C _1337_/D VGND VGND VPWR VPWR _1306_/B sky130_fd_sc_hd__or2_1
X_2285_ _2286_/CLK _2285_/D _1194_/X VGND VGND VPWR VPWR _2285_/Q sky130_fd_sc_hd__dfrtp_1
X_1098_ _1098_/A VGND VGND VPWR VPWR _2309_/D sky130_fd_sc_hd__inv_2
X_1167_ _1273_/A VGND VGND VPWR VPWR _1793_/A sky130_fd_sc_hd__buf_1
XFILLER_55_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2070_ _1937_/X _2293_/Q _2180_/D VGND VGND VPWR VPWR _2070_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1854_ _1854_/A VGND VGND VPWR VPWR _1854_/Y sky130_fd_sc_hd__inv_2
X_1923_ _2174_/Q _1266_/B _1267_/B VGND VGND VPWR VPWR _1923_/Y sky130_fd_sc_hd__a21boi_1
X_1785_ _1786_/A VGND VGND VPWR VPWR _1785_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_55_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1219_ _2065_/X _1216_/X _2284_/Q _1218_/X VGND VGND VPWR VPWR _2284_/D sky130_fd_sc_hd__a22o_1
X_2268_ _2268_/CLK _2268_/D _1257_/X VGND VGND VPWR VPWR _2268_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_37_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2199_ _2223_/CLK _2199_/D _1662_/X VGND VGND VPWR VPWR _2199_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_40_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_14_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2312_/CLK sky130_fd_sc_hd__clkbuf_16
XANTENNA_5 _2304_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1570_ _1576_/A VGND VGND VPWR VPWR _1819_/A sky130_fd_sc_hd__clkbuf_2
X_2053_ _1991_/Y _2289_/Q _2060_/S VGND VGND VPWR VPWR _2112_/D sky130_fd_sc_hd__mux2_2
X_2122_ _2224_/CLK _2122_/D VGND VGND VPWR VPWR _2122_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1906_ _2095_/X _1921_/B VGND VGND VPWR VPWR _2169_/D sky130_fd_sc_hd__nor2_1
X_1837_ _1840_/A _1837_/B VGND VGND VPWR VPWR _2146_/D sky130_fd_sc_hd__nor2_1
X_1768_ _1768_/A VGND VGND VPWR VPWR _1768_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_1_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1699_ _1699_/A VGND VGND VPWR VPWR _2194_/D sky130_fd_sc_hd__inv_2
XFILLER_40_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput20 _2121_/D VGND VGND VPWR VPWR scl_padoen_o sky130_fd_sc_hd__clkbuf_2
Xoutput31 _2119_/Q VGND VGND VPWR VPWR wb_dat_o[7] sky130_fd_sc_hd__clkbuf_2
XFILLER_56_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1622_ _2132_/Q VGND VGND VPWR VPWR _1809_/B sky130_fd_sc_hd__inv_2
XPHY_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1553_ _2185_/Q _1553_/B _1961_/B VGND VGND VPWR VPWR _1553_/X sky130_fd_sc_hd__or3_1
X_1484_ _1487_/A VGND VGND VPWR VPWR _1484_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_54_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2105_ _2104_/X _2194_/Q _2185_/Q VGND VGND VPWR VPWR _2105_/X sky130_fd_sc_hd__mux2_1
X_2036_ _2150_/D VGND VGND VPWR VPWR _2144_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1536_ _1523_/X _1527_/X _2105_/X _2220_/Q _1528_/X VGND VGND VPWR VPWR _2220_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_8_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1605_ _1611_/A VGND VGND VPWR VPWR _1605_/X sky130_fd_sc_hd__clkbuf_1
X_1467_ _1461_/Y _1460_/X _1466_/Y _1463_/X VGND VGND VPWR VPWR _2235_/D sky130_fd_sc_hd__o22ai_1
X_1398_ _1398_/A VGND VGND VPWR VPWR _2252_/D sky130_fd_sc_hd__inv_2
XFILLER_42_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2019_ _2124_/Q VGND VGND VPWR VPWR _2019_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1252_ _2068_/X _1243_/X _2271_/Q _1244_/X VGND VGND VPWR VPWR _2271_/D sky130_fd_sc_hd__a22o_1
X_1321_ _1377_/A _1337_/B _1337_/A VGND VGND VPWR VPWR _1322_/C sky130_fd_sc_hd__or3b_1
X_1183_ _1183_/A VGND VGND VPWR VPWR _2288_/D sky130_fd_sc_hd__inv_2
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1519_ _1510_/Y _1830_/B _2040_/B _2148_/D VGND VGND VPWR VPWR _1519_/X sky130_fd_sc_hd__a31o_1
XFILLER_55_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1870_ _2311_/Q _1896_/B _2127_/Q VGND VGND VPWR VPWR _2123_/D sky130_fd_sc_hd__and3_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1235_ _1248_/A VGND VGND VPWR VPWR _1246_/A sky130_fd_sc_hd__buf_1
XFILLER_56_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2284_ _2295_/CLK _2284_/D _1199_/X VGND VGND VPWR VPWR _2284_/Q sky130_fd_sc_hd__dfrtp_1
X_1166_ _1159_/X _1095_/A _1161_/X _2293_/Q _1156_/X VGND VGND VPWR VPWR _2293_/D
+ sky130_fd_sc_hd__o32a_1
X_1304_ _1313_/C _1324_/B VGND VGND VPWR VPWR _1337_/D sky130_fd_sc_hd__or2_2
XFILLER_52_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1097_ _1095_/Y _1073_/X _1085_/X _1096_/Y _1080_/X VGND VGND VPWR VPWR _1098_/A
+ sky130_fd_sc_hd__o32a_1
X_1999_ _2204_/Q VGND VGND VPWR VPWR _1999_/Y sky130_fd_sc_hd__inv_2
XFILLER_34_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1922_ _2303_/Q VGND VGND VPWR VPWR _1922_/Y sky130_fd_sc_hd__inv_2
XFILLER_46_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1853_ _1971_/A _1852_/Y _1579_/Y VGND VGND VPWR VPWR _2137_/D sky130_fd_sc_hd__o21ai_1
X_1784_ _1786_/A VGND VGND VPWR VPWR _1784_/X sky130_fd_sc_hd__clkbuf_1
X_1218_ _1244_/A VGND VGND VPWR VPWR _1218_/X sky130_fd_sc_hd__clkbuf_2
X_1149_ _1141_/X input8/X _1128_/B _2297_/Q _1132_/A VGND VGND VPWR VPWR _2297_/D
+ sky130_fd_sc_hd__o32a_1
X_2267_ _2267_/CLK _2267_/D _1276_/X VGND VGND VPWR VPWR _2267_/Q sky130_fd_sc_hd__dfstp_1
X_2198_ _2223_/CLK _2198_/D _1670_/X VGND VGND VPWR VPWR _2198_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_29_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_6 input7/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2121_ _2241_/CLK _2121_/D VGND VGND VPWR VPWR _2121_/Q sky130_fd_sc_hd__dfxtp_1
X_2052_ _2224_/Q _2261_/Q _2198_/Q VGND VGND VPWR VPWR _2052_/X sky130_fd_sc_hd__mux2_2
XFILLER_19_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1905_ _2169_/Q _1264_/B _1912_/C VGND VGND VPWR VPWR _1905_/Y sky130_fd_sc_hd__a21boi_1
XFILLER_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1698_ _1095_/Y _1113_/A _1696_/X _1697_/Y _1684_/X VGND VGND VPWR VPWR _1699_/A
+ sky130_fd_sc_hd__o32a_1
X_1767_ _1768_/A VGND VGND VPWR VPWR _1767_/X sky130_fd_sc_hd__clkbuf_1
X_1836_ _2183_/Q _1832_/Y _1510_/Y _1835_/Y _1799_/S VGND VGND VPWR VPWR _1837_/B
+ sky130_fd_sc_hd__o32a_1
XFILLER_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput21 _2050_/LO VGND VGND VPWR VPWR sda_pad_o sky130_fd_sc_hd__clkbuf_2
Xoutput32 _2123_/Q VGND VGND VPWR VPWR wb_inta_o sky130_fd_sc_hd__clkbuf_2
XFILLER_31_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1552_ _1667_/B VGND VGND VPWR VPWR _1961_/B sky130_fd_sc_hd__clkbuf_2
X_1621_ _1621_/A VGND VGND VPWR VPWR _2047_/C sky130_fd_sc_hd__clkbuf_2
XFILLER_39_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2104_ _2233_/Q _2219_/Q _2186_/Q VGND VGND VPWR VPWR _2104_/X sky130_fd_sc_hd__mux2_1
X_1483_ _1479_/Y _1460_/A _1664_/A _1463_/A VGND VGND VPWR VPWR _2230_/D sky130_fd_sc_hd__o22ai_1
X_2035_ _2144_/Q _2040_/B VGND VGND VPWR VPWR _2149_/D sky130_fd_sc_hd__and2_1
XFILLER_22_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1819_ _1819_/A _1819_/B VGND VGND VPWR VPWR _1820_/C sky130_fd_sc_hd__or2_1
XFILLER_26_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1535_ _1539_/A VGND VGND VPWR VPWR _1535_/X sky130_fd_sc_hd__clkbuf_1
X_1604_ _1604_/A VGND VGND VPWR VPWR _2205_/D sky130_fd_sc_hd__inv_2
X_1466_ _2234_/Q VGND VGND VPWR VPWR _1466_/Y sky130_fd_sc_hd__inv_2
X_1397_ _1396_/Y _1358_/A _1383_/Y _1330_/B _1361_/A VGND VGND VPWR VPWR _1398_/A
+ sky130_fd_sc_hd__o32a_1
X_2018_ _1820_/A _1978_/X _1692_/Y _1980_/A VGND VGND VPWR VPWR _2018_/X sky130_fd_sc_hd__o22a_1
XFILLER_2_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1320_ _2254_/Q VGND VGND VPWR VPWR _1337_/A sky130_fd_sc_hd__buf_1
X_1251_ _1257_/A VGND VGND VPWR VPWR _1251_/X sky130_fd_sc_hd__clkbuf_1
X_1182_ _1107_/Y _1113_/X _1061_/X _1180_/Y _1181_/X VGND VGND VPWR VPWR _1183_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_32_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_9_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2220_/CLK sky130_fd_sc_hd__clkbuf_16
X_1449_ _1449_/A VGND VGND VPWR VPWR _1449_/X sky130_fd_sc_hd__clkbuf_1
X_1518_ _1840_/A _1518_/B VGND VGND VPWR VPWR _2148_/D sky130_fd_sc_hd__nor2_1
XFILLER_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2283_ _2295_/CLK _2283_/D _1220_/X VGND VGND VPWR VPWR _2283_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1303_ _2258_/Q _2257_/Q _2256_/Q _2255_/Q VGND VGND VPWR VPWR _1324_/B sky130_fd_sc_hd__or4_4
X_1165_ _1165_/A VGND VGND VPWR VPWR _1165_/X sky130_fd_sc_hd__clkbuf_1
X_1234_ _2075_/X _1230_/X _2278_/Q _1231_/X VGND VGND VPWR VPWR _2278_/D sky130_fd_sc_hd__a22o_1
X_1096_ _2309_/Q VGND VGND VPWR VPWR _1096_/Y sky130_fd_sc_hd__inv_2
XFILLER_37_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1998_ _1180_/Y _1978_/X _1707_/Y _1980_/X VGND VGND VPWR VPWR _1998_/X sky130_fd_sc_hd__o22a_1
XFILLER_28_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1921_ _2093_/X _1921_/B VGND VGND VPWR VPWR _2173_/D sky130_fd_sc_hd__nor2_1
XFILLER_46_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1852_ _1653_/C _1851_/Y _1656_/Y VGND VGND VPWR VPWR _1852_/Y sky130_fd_sc_hd__a21oi_1
X_1783_ _1786_/A VGND VGND VPWR VPWR _1783_/X sky130_fd_sc_hd__clkbuf_1
X_2266_ _2267_/CLK _2266_/D _1278_/X VGND VGND VPWR VPWR _2266_/Q sky130_fd_sc_hd__dfstp_1
X_1217_ _1243_/A VGND VGND VPWR VPWR _1244_/A sky130_fd_sc_hd__inv_2
XFILLER_52_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1148_ _1165_/A VGND VGND VPWR VPWR _1148_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_37_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1079_ _1181_/B _1085_/A _1155_/A VGND VGND VPWR VPWR _1080_/A sky130_fd_sc_hd__o21ai_2
X_2197_ _2286_/CLK _2197_/D _1679_/X VGND VGND VPWR VPWR _2197_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_20_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2120_ _2250_/CLK _2120_/D VGND VGND VPWR VPWR _2120_/Q sky130_fd_sc_hd__dfxtp_2
Xclkbuf_leaf_23_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2229_/CLK sky130_fd_sc_hd__clkbuf_16
X_2051_ _2151_/Q _2260_/Q _2198_/Q VGND VGND VPWR VPWR _2121_/D sky130_fd_sc_hd__mux2_4
X_1904_ _2298_/Q VGND VGND VPWR VPWR _1904_/Y sky130_fd_sc_hd__inv_2
X_1835_ _2146_/Q VGND VGND VPWR VPWR _1835_/Y sky130_fd_sc_hd__inv_2
XFILLER_34_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1766_ _1768_/A VGND VGND VPWR VPWR _1766_/X sky130_fd_sc_hd__clkbuf_1
X_1697_ _2194_/Q VGND VGND VPWR VPWR _1697_/Y sky130_fd_sc_hd__inv_2
X_2249_ _2250_/CLK _2249_/D _1403_/X VGND VGND VPWR VPWR _2249_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_15_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput22 _2052_/X VGND VGND VPWR VPWR sda_padoen_o sky130_fd_sc_hd__clkbuf_2
XFILLER_56_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1551_ _1666_/C VGND VGND VPWR VPWR _1667_/B sky130_fd_sc_hd__inv_2
X_1482_ _2229_/Q VGND VGND VPWR VPWR _1664_/A sky130_fd_sc_hd__inv_2
X_1620_ _1620_/A VGND VGND VPWR VPWR _1621_/A sky130_fd_sc_hd__buf_1
XFILLER_54_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2103_ _2102_/X _2193_/Q _2185_/Q VGND VGND VPWR VPWR _2103_/X sky130_fd_sc_hd__mux2_1
X_2034_ _2120_/Q _2034_/B input7/X VGND VGND VPWR VPWR _2120_/D sky130_fd_sc_hd__and3b_1
X_1818_ _1818_/A _1842_/D _1820_/A _1818_/D VGND VGND VPWR VPWR _1818_/X sky130_fd_sc_hd__or4_4
X_1749_ _1750_/A VGND VGND VPWR VPWR _1749_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_26_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1465_ _1471_/A VGND VGND VPWR VPWR _1465_/X sky130_fd_sc_hd__clkbuf_1
X_1603_ _1100_/X _1989_/A _1118_/Y _1602_/Y _1588_/A VGND VGND VPWR VPWR _1604_/A
+ sky130_fd_sc_hd__o32a_1
X_1534_ _1523_/X _1527_/X _2107_/X _2221_/Q _1528_/X VGND VGND VPWR VPWR _2221_/D
+ sky130_fd_sc_hd__a32o_1
X_2017_ _1096_/Y _1976_/X _2012_/X _2015_/X _2016_/X VGND VGND VPWR VPWR _2017_/Y
+ sky130_fd_sc_hd__o2111ai_2
X_1396_ _2128_/Q VGND VGND VPWR VPWR _1396_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1250_ _2069_/X _1243_/X _2272_/Q _1244_/X VGND VGND VPWR VPWR _2272_/D sky130_fd_sc_hd__a22o_1
X_1181_ _1279_/A _1181_/B _1061_/X VGND VGND VPWR VPWR _1181_/X sky130_fd_sc_hd__or3b_4
XFILLER_32_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1448_ _1440_/Y _1446_/A _2239_/Q _1446_/Y _1879_/B VGND VGND VPWR VPWR _2239_/D
+ sky130_fd_sc_hd__o221a_1
XFILLER_4_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1517_ _1515_/Y _2184_/Q _1510_/Y _1830_/B _1516_/Y VGND VGND VPWR VPWR _1518_/B
+ sky130_fd_sc_hd__o32a_1
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1379_ _1379_/A _1379_/B VGND VGND VPWR VPWR _1380_/C sky130_fd_sc_hd__nand2_1
XFILLER_23_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1233_ _1233_/A VGND VGND VPWR VPWR _1233_/X sky130_fd_sc_hd__clkbuf_1
X_2282_ _2282_/CLK _2282_/D _1223_/X VGND VGND VPWR VPWR _2282_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1302_ _1374_/C _1372_/C VGND VGND VPWR VPWR _1313_/C sky130_fd_sc_hd__or2_1
XFILLER_52_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1164_ _1159_/X _1090_/A _1161_/X _2294_/Q _1156_/X VGND VGND VPWR VPWR _2294_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_37_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1095_ _1095_/A VGND VGND VPWR VPWR _1095_/Y sky130_fd_sc_hd__inv_2
X_1997_ _1114_/Y _1976_/X _1993_/X _1994_/X _1996_/X VGND VGND VPWR VPWR _1997_/Y
+ sky130_fd_sc_hd__o2111ai_2
XFILLER_20_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1920_ _1920_/A _1266_/B VGND VGND VPWR VPWR _1920_/Y sky130_fd_sc_hd__nor2b_1
X_1851_ _1851_/A _1851_/B VGND VGND VPWR VPWR _1851_/Y sky130_fd_sc_hd__nor2_2
X_1782_ _1786_/A VGND VGND VPWR VPWR _1782_/X sky130_fd_sc_hd__clkbuf_1
X_1216_ _1243_/A VGND VGND VPWR VPWR _1216_/X sky130_fd_sc_hd__clkbuf_2
X_2265_ _2267_/CLK _2265_/D _1282_/X VGND VGND VPWR VPWR _2265_/Q sky130_fd_sc_hd__dfstp_1
X_2196_ _2286_/CLK _2196_/D _1687_/X VGND VGND VPWR VPWR _2196_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_52_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1147_ _2048_/A VGND VGND VPWR VPWR _1165_/A sky130_fd_sc_hd__buf_1
X_1078_ _1078_/A VGND VGND VPWR VPWR _1155_/A sky130_fd_sc_hd__buf_2
XFILLER_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2050_ VGND VGND VPWR VPWR _2050_/HI _2050_/LO sky130_fd_sc_hd__conb_1
XFILLER_34_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1903_ _2312_/Q _1909_/B _2085_/X VGND VGND VPWR VPWR _2168_/D sky130_fd_sc_hd__and3_1
X_1765_ _1768_/A VGND VGND VPWR VPWR _1765_/X sky130_fd_sc_hd__clkbuf_1
X_1834_ _2149_/Q _1840_/A _1834_/C VGND VGND VPWR VPWR _2143_/D sky130_fd_sc_hd__or3_1
X_1696_ _1985_/A VGND VGND VPWR VPWR _1696_/X sky130_fd_sc_hd__buf_1
X_2179_ _2234_/CLK _2179_/D _1730_/X VGND VGND VPWR VPWR _2179_/Q sky130_fd_sc_hd__dfrtp_1
X_2248_ _2250_/CLK _2248_/D _1405_/X VGND VGND VPWR VPWR _2248_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_40_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput23 _2120_/Q VGND VGND VPWR VPWR wb_ack_o sky130_fd_sc_hd__clkbuf_2
XFILLER_0_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1550_ _2214_/Q _2213_/Q _2215_/Q VGND VGND VPWR VPWR _1666_/C sky130_fd_sc_hd__or3_4
X_1481_ _1487_/A VGND VGND VPWR VPWR _1481_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2033_ _1682_/Y _1980_/X _1202_/A _1976_/A _2032_/X VGND VGND VPWR VPWR _2033_/Y
+ sky130_fd_sc_hd__o221ai_2
X_2102_ _2232_/Q _2218_/Q _2186_/Q VGND VGND VPWR VPWR _2102_/X sky130_fd_sc_hd__mux2_1
X_1748_ _1750_/A VGND VGND VPWR VPWR _1748_/X sky130_fd_sc_hd__clkbuf_1
X_1817_ _1860_/A VGND VGND VPWR VPWR _1971_/A sky130_fd_sc_hd__clkbuf_2
X_1679_ _1700_/A VGND VGND VPWR VPWR _1679_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_53_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1602_ _2205_/Q VGND VGND VPWR VPWR _1602_/Y sky130_fd_sc_hd__inv_2
X_1464_ _1631_/A _1460_/X _1461_/Y _1463_/X VGND VGND VPWR VPWR _2236_/D sky130_fd_sc_hd__o22ai_1
X_1533_ _1539_/A VGND VGND VPWR VPWR _1533_/X sky130_fd_sc_hd__clkbuf_1
X_1395_ _1405_/A VGND VGND VPWR VPWR _1395_/X sky130_fd_sc_hd__clkbuf_1
X_2016_ _1915_/Y _1988_/X _1633_/Y _1989_/X VGND VGND VPWR VPWR _2016_/X sky130_fd_sc_hd__o22a_1
XFILLER_27_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1180_ _2288_/Q VGND VGND VPWR VPWR _1180_/Y sky130_fd_sc_hd__inv_2
X_1516_ _2158_/Q _1829_/A VGND VGND VPWR VPWR _1516_/Y sky130_fd_sc_hd__nor2_1
X_1447_ _1462_/A VGND VGND VPWR VPWR _1879_/B sky130_fd_sc_hd__inv_2
X_1378_ _1378_/A _1378_/B _1378_/C _1378_/D VGND VGND VPWR VPWR _1380_/A sky130_fd_sc_hd__nand4_2
XFILLER_23_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_17_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2222_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_13_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2281_ _2303_/CLK _2281_/D _1225_/X VGND VGND VPWR VPWR _2281_/Q sky130_fd_sc_hd__dfrtp_1
X_1232_ _2076_/X _1230_/X _2279_/Q _1231_/X VGND VGND VPWR VPWR _2279_/D sky130_fd_sc_hd__a22o_1
X_1301_ _2246_/Q _2245_/Q _2244_/Q _2243_/Q VGND VGND VPWR VPWR _1372_/C sky130_fd_sc_hd__or4_4
X_1163_ _1165_/A VGND VGND VPWR VPWR _1163_/X sky130_fd_sc_hd__clkbuf_1
X_1094_ _1099_/A VGND VGND VPWR VPWR _1094_/X sky130_fd_sc_hd__clkbuf_1
X_1996_ _1995_/Y _1983_/X _1711_/Y _1980_/X VGND VGND VPWR VPWR _1996_/X sky130_fd_sc_hd__o22a_1
XFILLER_55_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1781_ _1793_/A VGND VGND VPWR VPWR _1786_/A sky130_fd_sc_hd__clkbuf_2
X_1850_ _1406_/Y _1848_/Y _1826_/X VGND VGND VPWR VPWR _2130_/D sky130_fd_sc_hd__o21ai_1
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1146_ _1141_/X input9/X _1133_/A _2298_/Q _1132_/A VGND VGND VPWR VPWR _2298_/D
+ sky130_fd_sc_hd__o32a_1
X_2264_ _2268_/CLK _2264_/D _1284_/X VGND VGND VPWR VPWR _2264_/Q sky130_fd_sc_hd__dfstp_1
X_1215_ _1215_/A _2180_/D VGND VGND VPWR VPWR _1243_/A sky130_fd_sc_hd__or2_4
XFILLER_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2195_ _2287_/CLK _2195_/D _1691_/X VGND VGND VPWR VPWR _2195_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_1_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1077_ _1151_/A VGND VGND VPWR VPWR _1181_/B sky130_fd_sc_hd__clkbuf_2
X_1979_ input5/X _1979_/B _1979_/C VGND VGND VPWR VPWR _1980_/A sky130_fd_sc_hd__or3_4
XFILLER_20_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1902_ _2168_/Q _1263_/B _1264_/B VGND VGND VPWR VPWR _1902_/X sky130_fd_sc_hd__a21bo_1
XFILLER_34_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1764_ _1768_/A VGND VGND VPWR VPWR _1764_/X sky130_fd_sc_hd__clkbuf_1
X_1833_ _1515_/Y _2184_/Q _2183_/Q _1832_/Y _2143_/Q VGND VGND VPWR VPWR _1834_/C
+ sky130_fd_sc_hd__o221a_1
X_1695_ _1700_/A VGND VGND VPWR VPWR _1695_/X sky130_fd_sc_hd__clkbuf_1
X_1129_ _1132_/A VGND VGND VPWR VPWR _1129_/X sky130_fd_sc_hd__clkbuf_2
X_2178_ _2241_/CLK _2178_/D _1731_/X VGND VGND VPWR VPWR _2178_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_25_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2247_ _2250_/CLK _2247_/D _1410_/X VGND VGND VPWR VPWR _2247_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_13_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput24 _2112_/Q VGND VGND VPWR VPWR wb_dat_o[0] sky130_fd_sc_hd__clkbuf_2
XFILLER_56_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1480_ _1476_/Y _1460_/A _1479_/Y _1463_/A VGND VGND VPWR VPWR _2231_/D sky130_fd_sc_hd__o22ai_1
XFILLER_39_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2032_ _1961_/A _1985_/A _1925_/Y _1988_/A _2031_/X VGND VGND VPWR VPWR _2032_/X
+ sky130_fd_sc_hd__o221a_1
X_2101_ _2100_/X _2192_/Q _2185_/Q VGND VGND VPWR VPWR _2101_/X sky130_fd_sc_hd__mux2_1
X_1816_ _2141_/Q VGND VGND VPWR VPWR _1960_/D sky130_fd_sc_hd__inv_2
X_1747_ _1750_/A VGND VGND VPWR VPWR _1747_/X sky130_fd_sc_hd__clkbuf_1
X_1678_ _1678_/A VGND VGND VPWR VPWR _1700_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_53_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1601_ _1611_/A VGND VGND VPWR VPWR _1601_/X sky130_fd_sc_hd__clkbuf_1
X_1532_ _1523_/X _1527_/X _2109_/X _2222_/Q _1528_/X VGND VGND VPWR VPWR _2222_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_12_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1463_ _1463_/A VGND VGND VPWR VPWR _1463_/X sky130_fd_sc_hd__clkbuf_2
X_1394_ _1409_/A VGND VGND VPWR VPWR _1405_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_35_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2015_ _2013_/Y _1983_/X _2014_/Y _1985_/X VGND VGND VPWR VPWR _2015_/X sky130_fd_sc_hd__o22a_1
XFILLER_53_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1515_ _2183_/Q VGND VGND VPWR VPWR _1515_/Y sky130_fd_sc_hd__inv_2
X_1446_ _1446_/A VGND VGND VPWR VPWR _1446_/Y sky130_fd_sc_hd__inv_2
XFILLER_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1377_ _1377_/A _2246_/Q _1377_/C _2245_/Q VGND VGND VPWR VPWR _1378_/D sky130_fd_sc_hd__or4b_4
XFILLER_23_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2280_ _2295_/CLK _2280_/D _1227_/X VGND VGND VPWR VPWR _2280_/Q sky130_fd_sc_hd__dfrtp_1
X_1231_ _1244_/A VGND VGND VPWR VPWR _1231_/X sky130_fd_sc_hd__clkbuf_2
X_1162_ _1159_/X _1084_/A _1161_/X _2295_/Q _1156_/X VGND VGND VPWR VPWR _2295_/D
+ sky130_fd_sc_hd__o32a_1
X_1300_ _2248_/Q _2247_/Q _2250_/Q _2249_/Q VGND VGND VPWR VPWR _1374_/C sky130_fd_sc_hd__or4_4
X_1093_ _1093_/A VGND VGND VPWR VPWR _2310_/D sky130_fd_sc_hd__inv_2
X_1995_ _2126_/Q VGND VGND VPWR VPWR _1995_/Y sky130_fd_sc_hd__inv_2
XFILLER_20_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1429_ _2239_/Q _2238_/Q _2237_/Q VGND VGND VPWR VPWR _1437_/D sky130_fd_sc_hd__or3_1
XFILLER_18_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1780_ _1780_/A VGND VGND VPWR VPWR _1780_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_10_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1145_ _1145_/A VGND VGND VPWR VPWR _1145_/X sky130_fd_sc_hd__clkbuf_1
X_2263_ _2268_/CLK _2263_/D _1286_/X VGND VGND VPWR VPWR _2263_/Q sky130_fd_sc_hd__dfstp_1
X_1214_ _1441_/A _2160_/Q _2121_/D _1927_/B _1213_/Y VGND VGND VPWR VPWR _2180_/D
+ sky130_fd_sc_hd__a311o_4
X_2194_ _2287_/CLK _2194_/D _1695_/X VGND VGND VPWR VPWR _2194_/Q sky130_fd_sc_hd__dfrtp_1
X_1076_ _1085_/A VGND VGND VPWR VPWR _1976_/A sky130_fd_sc_hd__clkbuf_2
X_1978_ _1978_/A VGND VGND VPWR VPWR _1978_/X sky130_fd_sc_hd__dlymetal6s2s_1
Xclkbuf_leaf_2_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2241_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_29_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1901_ _1901_/A _1909_/B _2080_/X VGND VGND VPWR VPWR _2167_/D sky130_fd_sc_hd__and3_1
X_1832_ _2184_/Q VGND VGND VPWR VPWR _1832_/Y sky130_fd_sc_hd__inv_2
X_1763_ _1769_/A VGND VGND VPWR VPWR _1768_/A sky130_fd_sc_hd__clkbuf_2
X_1694_ _1694_/A VGND VGND VPWR VPWR _2195_/D sky130_fd_sc_hd__inv_2
X_2246_ _2254_/CLK _2246_/D _1412_/X VGND VGND VPWR VPWR _2246_/Q sky130_fd_sc_hd__dfrtp_1
X_2177_ _2268_/CLK _2177_/D _1733_/X VGND VGND VPWR VPWR _2177_/Q sky130_fd_sc_hd__dfrtp_1
X_1128_ _1155_/A _1128_/B VGND VGND VPWR VPWR _1132_/A sky130_fd_sc_hd__nand2_2
X_1059_ input6/X VGND VGND VPWR VPWR _1979_/C sky130_fd_sc_hd__inv_2
XFILLER_15_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xoutput25 _2113_/Q VGND VGND VPWR VPWR wb_dat_o[1] sky130_fd_sc_hd__clkbuf_2
XFILLER_56_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2100_ _2231_/Q _2217_/Q _2186_/Q VGND VGND VPWR VPWR _2100_/X sky130_fd_sc_hd__mux2_1
X_2031_ _2030_/Y _1983_/A _1674_/A _1978_/A VGND VGND VPWR VPWR _2031_/X sky130_fd_sc_hd__o22a_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1815_ _2153_/Q VGND VGND VPWR VPWR _1962_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1746_ _1750_/A VGND VGND VPWR VPWR _1746_/X sky130_fd_sc_hd__clkbuf_1
X_1677_ _1675_/Y _1676_/X _2047_/C VGND VGND VPWR VPWR _2198_/D sky130_fd_sc_hd__o21a_1
X_2229_ _2229_/CLK _2229_/D _1484_/X VGND VGND VPWR VPWR _2229_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_21_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1600_ _1280_/A input9/X _1587_/A _2206_/Q _1588_/A VGND VGND VPWR VPWR _2206_/D
+ sky130_fd_sc_hd__o32a_1
X_1462_ _1462_/A _1462_/B VGND VGND VPWR VPWR _1463_/A sky130_fd_sc_hd__or2_2
X_1531_ _1539_/A VGND VGND VPWR VPWR _1531_/X sky130_fd_sc_hd__clkbuf_1
X_1393_ _1332_/D _1391_/X _1337_/B _1392_/X VGND VGND VPWR VPWR _2253_/D sky130_fd_sc_hd__a2bb2o_1
X_2014_ _2220_/Q VGND VGND VPWR VPWR _2014_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1729_ _1731_/A VGND VGND VPWR VPWR _1729_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_37_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1445_ _2238_/Q _1454_/A VGND VGND VPWR VPWR _1446_/A sky130_fd_sc_hd__or2_1
XFILLER_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1514_ _1520_/C VGND VGND VPWR VPWR _2040_/B sky130_fd_sc_hd__clkbuf_2
X_1376_ _1377_/A _2250_/Q _1376_/C _2249_/Q VGND VGND VPWR VPWR _1378_/C sky130_fd_sc_hd__or4b_4
XFILLER_46_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1161_ _1161_/A VGND VGND VPWR VPWR _1161_/X sky130_fd_sc_hd__buf_1
XFILLER_49_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1230_ _1243_/A VGND VGND VPWR VPWR _1230_/X sky130_fd_sc_hd__clkbuf_2
X_1092_ _1090_/Y _1073_/X _1085_/X _1091_/Y _1080_/X VGND VGND VPWR VPWR _1093_/A
+ sky130_fd_sc_hd__o32a_1
Xclkbuf_leaf_26_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2254_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_1_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1994_ _1187_/X _1978_/A _1630_/Y _1989_/A VGND VGND VPWR VPWR _1994_/X sky130_fd_sc_hd__o22a_1
XFILLER_20_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1428_ _2241_/Q VGND VGND VPWR VPWR _1437_/C sky130_fd_sc_hd__inv_2
XFILLER_28_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1359_ _1391_/A VGND VGND VPWR VPWR _1359_/X sky130_fd_sc_hd__buf_1
XFILLER_50_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1213_ _1213_/A VGND VGND VPWR VPWR _1213_/Y sky130_fd_sc_hd__inv_2
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2262_ _2262_/CLK _2262_/D _1289_/X VGND VGND VPWR VPWR _2262_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_52_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1144_ _1141_/X _1107_/A _1133_/X _2299_/Q _1132_/A VGND VGND VPWR VPWR _2299_/D
+ sky130_fd_sc_hd__o32a_1
X_1075_ _1977_/A input4/X input6/X VGND VGND VPWR VPWR _1085_/A sky130_fd_sc_hd__or3_4
X_2193_ _2311_/CLK _2193_/D _1700_/X VGND VGND VPWR VPWR _2193_/Q sky130_fd_sc_hd__dfrtp_1
X_1977_ _1977_/A input4/X _1979_/C VGND VGND VPWR VPWR _1978_/A sky130_fd_sc_hd__or3_4
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1900_ _2167_/Q _1897_/X _1263_/B VGND VGND VPWR VPWR _1900_/X sky130_fd_sc_hd__a21bo_1
XFILLER_42_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1831_ _2042_/A _1829_/Y _2147_/Q _1830_/Y _2040_/B VGND VGND VPWR VPWR _2147_/D
+ sky130_fd_sc_hd__o221a_1
X_1693_ _1090_/Y _1501_/X _1681_/X _1692_/Y _1684_/X VGND VGND VPWR VPWR _1694_/A
+ sky130_fd_sc_hd__o32a_1
X_1762_ _1762_/A VGND VGND VPWR VPWR _1762_/X sky130_fd_sc_hd__clkbuf_1
X_2176_ _2268_/CLK _2176_/D _1734_/X VGND VGND VPWR VPWR _2176_/Q sky130_fd_sc_hd__dfrtp_1
X_2245_ _2254_/CLK _2245_/D _1414_/X VGND VGND VPWR VPWR _2245_/Q sky130_fd_sc_hd__dfrtp_1
X_1058_ _2312_/Q VGND VGND VPWR VPWR _1202_/A sky130_fd_sc_hd__inv_2
X_1127_ _1151_/A _1988_/A VGND VGND VPWR VPWR _1128_/B sky130_fd_sc_hd__or2_2
XFILLER_33_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput26 _2114_/Q VGND VGND VPWR VPWR wb_dat_o[2] sky130_fd_sc_hd__clkbuf_2
XFILLER_56_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2030_ _2125_/Q VGND VGND VPWR VPWR _2030_/Y sky130_fd_sc_hd__inv_2
XFILLER_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1745_ _1769_/A VGND VGND VPWR VPWR _1750_/A sky130_fd_sc_hd__buf_1
XFILLER_30_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1814_ _1814_/A _1814_/B _1813_/X VGND VGND VPWR VPWR _2140_/D sky130_fd_sc_hd__or3b_2
X_1676_ _2198_/Q _1676_/B VGND VGND VPWR VPWR _1676_/X sky130_fd_sc_hd__and2_1
XFILLER_38_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2159_ _2267_/CLK _2159_/D _1755_/X VGND VGND VPWR VPWR _2159_/Q sky130_fd_sc_hd__dfstp_1
X_2228_ _2286_/CLK _2228_/D _1487_/X VGND VGND VPWR VPWR _2228_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_42_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1461_ _2235_/Q VGND VGND VPWR VPWR _1461_/Y sky130_fd_sc_hd__inv_2
X_1530_ _1530_/A VGND VGND VPWR VPWR _1539_/A sky130_fd_sc_hd__clkbuf_2
X_1392_ _1392_/A VGND VGND VPWR VPWR _1392_/X sky130_fd_sc_hd__buf_1
XFILLER_8_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2013_ _2285_/Q VGND VGND VPWR VPWR _2013_/Y sky130_fd_sc_hd__inv_2
XFILLER_35_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1728_ _1731_/A VGND VGND VPWR VPWR _1728_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_12_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1659_ _2200_/Q VGND VGND VPWR VPWR _1975_/A sky130_fd_sc_hd__inv_2
XFILLER_41_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1444_ _2237_/Q _1462_/B VGND VGND VPWR VPWR _1454_/A sky130_fd_sc_hd__or2_1
XFILLER_4_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1375_ _1375_/A _1377_/C _2245_/Q _2246_/Q VGND VGND VPWR VPWR _1378_/B sky130_fd_sc_hd__or4b_4
X_1513_ _1840_/A VGND VGND VPWR VPWR _1520_/C sky130_fd_sc_hd__inv_2
XFILLER_23_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1160_ _1160_/A VGND VGND VPWR VPWR _1161_/A sky130_fd_sc_hd__inv_2
X_1091_ _2310_/Q VGND VGND VPWR VPWR _1091_/Y sky130_fd_sc_hd__inv_2
X_1993_ _1904_/Y _1988_/A _1992_/Y _1985_/X VGND VGND VPWR VPWR _1993_/X sky130_fd_sc_hd__o22a_1
XFILLER_9_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1427_ _2156_/Q VGND VGND VPWR VPWR _1462_/A sky130_fd_sc_hd__clkbuf_2
X_1358_ _1358_/A VGND VGND VPWR VPWR _1391_/A sky130_fd_sc_hd__buf_1
X_1289_ _1365_/A VGND VGND VPWR VPWR _1289_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_50_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1212_ _2282_/Q _2281_/Q _1212_/C _1950_/B VGND VGND VPWR VPWR _1213_/A sky130_fd_sc_hd__or4_4
X_2192_ _2287_/CLK _2192_/D _1706_/X VGND VGND VPWR VPWR _2192_/Q sky130_fd_sc_hd__dfrtp_4
X_2261_ _2261_/CLK _2261_/D _1292_/X VGND VGND VPWR VPWR _2261_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_52_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1143_ _1145_/A VGND VGND VPWR VPWR _1143_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_37_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1074_ input5/X VGND VGND VPWR VPWR _1977_/A sky130_fd_sc_hd__inv_2
XFILLER_25_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1976_ _1976_/A VGND VGND VPWR VPWR _1976_/X sky130_fd_sc_hd__clkbuf_4
XFILLER_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1830_ _2158_/Q _1830_/B VGND VGND VPWR VPWR _1830_/Y sky130_fd_sc_hd__nor2_1
XFILLER_42_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1761_ _1762_/A VGND VGND VPWR VPWR _1761_/X sky130_fd_sc_hd__clkbuf_1
X_2313_ _2313_/CLK _2313_/D _2048_/X VGND VGND VPWR VPWR _2313_/Q sky130_fd_sc_hd__dfrtp_2
X_1692_ _2195_/Q VGND VGND VPWR VPWR _1692_/Y sky130_fd_sc_hd__inv_2
X_2175_ _2268_/CLK _2175_/D _1735_/X VGND VGND VPWR VPWR _2175_/Q sky130_fd_sc_hd__dfrtp_1
Xclkbuf_leaf_10_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2313_/CLK sky130_fd_sc_hd__clkbuf_16
X_1126_ input5/X _1979_/B input6/X VGND VGND VPWR VPWR _1988_/A sky130_fd_sc_hd__or3_4
X_2244_ _2254_/CLK _2244_/D _1416_/X VGND VGND VPWR VPWR _2244_/Q sky130_fd_sc_hd__dfrtp_1
X_1057_ _1057_/A _2120_/Q VGND VGND VPWR VPWR _1070_/A sky130_fd_sc_hd__nand2_1
XFILLER_33_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1959_ _2223_/Q VGND VGND VPWR VPWR _1961_/A sky130_fd_sc_hd__inv_2
XFILLER_48_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput27 _2115_/Q VGND VGND VPWR VPWR wb_dat_o[3] sky130_fd_sc_hd__clkbuf_2
XFILLER_0_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1744_ _1744_/A VGND VGND VPWR VPWR _1769_/A sky130_fd_sc_hd__clkbuf_2
X_1813_ _2226_/Q _1818_/D _1813_/C VGND VGND VPWR VPWR _1813_/X sky130_fd_sc_hd__or3_1
X_1675_ _1675_/A VGND VGND VPWR VPWR _1675_/Y sky130_fd_sc_hd__inv_2
XFILLER_53_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2089_ _1916_/Y _1915_/Y _2095_/S VGND VGND VPWR VPWR _2089_/X sky130_fd_sc_hd__mux2_1
X_1109_ _1107_/Y _1073_/X _1085_/X _1108_/Y _1080_/A VGND VGND VPWR VPWR _1110_/A
+ sky130_fd_sc_hd__o32a_1
X_2158_ _2267_/CLK _2158_/D _1756_/X VGND VGND VPWR VPWR _2158_/Q sky130_fd_sc_hd__dfstp_1
X_2227_ _2287_/CLK _2227_/D _1495_/X VGND VGND VPWR VPWR _2227_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_42_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1460_ _1460_/A VGND VGND VPWR VPWR _1460_/X sky130_fd_sc_hd__clkbuf_2
X_1391_ _1391_/A VGND VGND VPWR VPWR _1391_/X sky130_fd_sc_hd__buf_1
XFILLER_35_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2012_ _1506_/Y _1978_/X _1697_/Y _1980_/A VGND VGND VPWR VPWR _2012_/X sky130_fd_sc_hd__o22a_1
XFILLER_50_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1727_ _1731_/A VGND VGND VPWR VPWR _1727_/X sky130_fd_sc_hd__clkbuf_1
X_1658_ _1658_/A VGND VGND VPWR VPWR _1658_/Y sky130_fd_sc_hd__inv_2
X_1589_ _1175_/X _1084_/A _1587_/X _2211_/Q _1588_/X VGND VGND VPWR VPWR _2211_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_37_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1512_ _2156_/Q _1927_/B VGND VGND VPWR VPWR _1840_/A sky130_fd_sc_hd__or2_2
X_1443_ _1459_/B VGND VGND VPWR VPWR _1462_/B sky130_fd_sc_hd__inv_2
XFILLER_4_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1374_ _2244_/Q _2243_/Q _1374_/C _1374_/D VGND VGND VPWR VPWR _1377_/C sky130_fd_sc_hd__or4_4
XFILLER_31_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1090_ _1090_/A VGND VGND VPWR VPWR _1090_/Y sky130_fd_sc_hd__inv_2
X_1992_ _2217_/Q VGND VGND VPWR VPWR _1992_/Y sky130_fd_sc_hd__inv_2
XFILLER_13_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1426_ _1449_/A VGND VGND VPWR VPWR _1426_/X sky130_fd_sc_hd__clkbuf_1
X_1357_ _1357_/A _1357_/B VGND VGND VPWR VPWR _1358_/A sky130_fd_sc_hd__or2_2
X_1288_ _1409_/A VGND VGND VPWR VPWR _1365_/A sky130_fd_sc_hd__buf_1
XFILLER_34_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1211_ _2278_/Q _2277_/Q _1211_/C _1942_/B VGND VGND VPWR VPWR _1950_/B sky130_fd_sc_hd__or4_4
X_1142_ _1141_/X _1101_/B _1133_/X _2300_/Q _1129_/X VGND VGND VPWR VPWR _2300_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_37_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2191_ _2287_/CLK _2191_/D _1710_/X VGND VGND VPWR VPWR _2191_/Q sky130_fd_sc_hd__dfrtp_1
X_2260_ _2260_/CLK _2260_/D _1342_/X VGND VGND VPWR VPWR _2260_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1073_ _1113_/A VGND VGND VPWR VPWR _1073_/X sky130_fd_sc_hd__clkbuf_2
X_1975_ _1975_/A _1975_/B VGND VGND VPWR VPWR _2184_/D sky130_fd_sc_hd__nor2_1
X_1409_ _1409_/A VGND VGND VPWR VPWR _1418_/A sky130_fd_sc_hd__buf_1
XFILLER_36_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1691_ _1700_/A VGND VGND VPWR VPWR _1691_/X sky130_fd_sc_hd__clkbuf_1
X_1760_ _1762_/A VGND VGND VPWR VPWR _1760_/X sky130_fd_sc_hd__clkbuf_1
X_2312_ _2312_/CLK _2312_/D _1099_/A VGND VGND VPWR VPWR _2312_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2174_ _2282_/CLK _2174_/D _1736_/X VGND VGND VPWR VPWR _2174_/Q sky130_fd_sc_hd__dfrtp_1
X_1125_ input4/X VGND VGND VPWR VPWR _1979_/B sky130_fd_sc_hd__inv_2
X_2243_ _2250_/CLK _2243_/D _1418_/X VGND VGND VPWR VPWR _2243_/Q sky130_fd_sc_hd__dfrtp_4
X_1056_ _1540_/A VGND VGND VPWR VPWR _1909_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_33_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1889_ _2091_/X _1921_/B VGND VGND VPWR VPWR _2162_/D sky130_fd_sc_hd__nor2_1
Xoutput28 _2116_/Q VGND VGND VPWR VPWR wb_dat_o[4] sky130_fd_sc_hd__clkbuf_2
X_1958_ _2122_/Q _2186_/Q VGND VGND VPWR VPWR _1958_/X sky130_fd_sc_hd__and2_1
XFILLER_56_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1743_ _1743_/A VGND VGND VPWR VPWR _1743_/X sky130_fd_sc_hd__clkbuf_1
X_1812_ _1506_/Y _1825_/C _1819_/B _1810_/X _1842_/D VGND VGND VPWR VPWR _1813_/C
+ sky130_fd_sc_hd__o32a_1
X_1674_ _1674_/A _1674_/B VGND VGND VPWR VPWR _1675_/A sky130_fd_sc_hd__or2_2
X_2226_ _2286_/CLK _2226_/D _1500_/X VGND VGND VPWR VPWR _2226_/Q sky130_fd_sc_hd__dfrtp_1
X_2088_ _1913_/X _1910_/Y _2095_/S VGND VGND VPWR VPWR _2088_/X sky130_fd_sc_hd__mux2_1
X_1108_ _2307_/Q VGND VGND VPWR VPWR _1108_/Y sky130_fd_sc_hd__inv_2
X_2157_ _2260_/CLK _2157_/D _1758_/X VGND VGND VPWR VPWR _2157_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_26_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1390_ _1390_/A VGND VGND VPWR VPWR _1390_/X sky130_fd_sc_hd__clkbuf_1
X_2011_ _1102_/Y _1976_/X _2006_/X _2009_/X _2010_/X VGND VGND VPWR VPWR _2011_/Y
+ sky130_fd_sc_hd__o2111ai_4
X_1588_ _1588_/A VGND VGND VPWR VPWR _1588_/X sky130_fd_sc_hd__buf_1
X_1726_ _1738_/A VGND VGND VPWR VPWR _1731_/A sky130_fd_sc_hd__buf_1
X_1657_ _1960_/B _1653_/X _1819_/A _1656_/Y VGND VGND VPWR VPWR _1658_/A sky130_fd_sc_hd__a211o_1
X_2209_ _2234_/CLK _2209_/D _1592_/X VGND VGND VPWR VPWR _2209_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_26_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1442_ _2241_/Q _1799_/S _1442_/C VGND VGND VPWR VPWR _1459_/B sky130_fd_sc_hd__and3_1
X_1511_ _2148_/Q VGND VGND VPWR VPWR _1830_/B sky130_fd_sc_hd__inv_2
X_1373_ _1375_/A _1376_/C _2249_/Q _2250_/Q VGND VGND VPWR VPWR _1378_/A sky130_fd_sc_hd__or4b_4
XFILLER_23_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1709_ _1709_/A VGND VGND VPWR VPWR _2192_/D sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_5_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2172_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_49_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1991_ _1119_/Y _1976_/X _1981_/X _1986_/X _1990_/X VGND VGND VPWR VPWR _1991_/Y
+ sky130_fd_sc_hd__o2111ai_2
X_1425_ _1880_/B _1343_/A _1383_/B _2242_/Q _1363_/A VGND VGND VPWR VPWR _2242_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_55_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1287_ _2177_/Q _1269_/A _2263_/Q _1270_/A _1280_/X VGND VGND VPWR VPWR _2263_/D
+ sky130_fd_sc_hd__a221o_1
X_1356_ _1356_/A _1356_/B VGND VGND VPWR VPWR _1383_/A sky130_fd_sc_hd__or2_1
XFILLER_18_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1210_ _2276_/Q _1210_/B VGND VGND VPWR VPWR _1942_/B sky130_fd_sc_hd__or2_2
XFILLER_49_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1141_ _1271_/A VGND VGND VPWR VPWR _1141_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_37_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1072_ _1501_/A VGND VGND VPWR VPWR _1113_/A sky130_fd_sc_hd__buf_1
X_2190_ _2287_/CLK _2190_/D _1714_/X VGND VGND VPWR VPWR _2190_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1974_ _1974_/A _1975_/B VGND VGND VPWR VPWR _2183_/D sky130_fd_sc_hd__nor2_1
X_1408_ _1408_/A VGND VGND VPWR VPWR _2248_/D sky130_fd_sc_hd__inv_2
XPHY_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1339_ _1356_/A _1334_/X _1880_/B _1337_/X _1338_/X VGND VGND VPWR VPWR _1339_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_51_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1690_ _1690_/A VGND VGND VPWR VPWR _2196_/D sky130_fd_sc_hd__inv_2
X_2311_ _2311_/CLK _2311_/D _1083_/X VGND VGND VPWR VPWR _2311_/Q sky130_fd_sc_hd__dfrtp_1
X_2242_ _2260_/CLK _2242_/D _1424_/X VGND VGND VPWR VPWR _2242_/Q sky130_fd_sc_hd__dfrtp_1
X_2173_ _2268_/CLK _2173_/D _1737_/X VGND VGND VPWR VPWR _2173_/Q sky130_fd_sc_hd__dfrtp_1
X_1124_ _1271_/A VGND VGND VPWR VPWR _1124_/X sky130_fd_sc_hd__clkbuf_2
X_1055_ _1078_/A VGND VGND VPWR VPWR _1540_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_18_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1957_ _1956_/Y _1954_/Y _1213_/A VGND VGND VPWR VPWR _1957_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_33_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1888_ _1927_/B VGND VGND VPWR VPWR _1921_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_0_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput29 _2117_/Q VGND VGND VPWR VPWR wb_dat_o[5] sky130_fd_sc_hd__clkbuf_2
XFILLER_56_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1811_ _2142_/Q VGND VGND VPWR VPWR _1842_/D sky130_fd_sc_hd__inv_2
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1742_ _1743_/A VGND VGND VPWR VPWR _1742_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_7_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1673_ _1960_/B _1819_/B VGND VGND VPWR VPWR _1674_/B sky130_fd_sc_hd__or2_1
XFILLER_38_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2225_ _2286_/CLK _2225_/D _1505_/X VGND VGND VPWR VPWR _2225_/Q sky130_fd_sc_hd__dfrtp_1
X_2087_ _1908_/X _2299_/Q _2095_/S VGND VGND VPWR VPWR _2087_/X sky130_fd_sc_hd__mux2_1
X_1107_ _1107_/A VGND VGND VPWR VPWR _1107_/Y sky130_fd_sc_hd__inv_2
X_2156_ _2260_/CLK _2156_/D _1759_/X VGND VGND VPWR VPWR _2156_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_44_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2010_ _1910_/Y _1988_/X _1624_/Y _1989_/X VGND VGND VPWR VPWR _2010_/X sky130_fd_sc_hd__o22a_1
X_1725_ _1725_/A VGND VGND VPWR VPWR _1725_/X sky130_fd_sc_hd__clkbuf_1
X_1587_ _1587_/A VGND VGND VPWR VPWR _1587_/X sky130_fd_sc_hd__buf_1
X_1656_ _1676_/B VGND VGND VPWR VPWR _1656_/Y sky130_fd_sc_hd__inv_2
X_2208_ _2234_/CLK _2208_/D _1594_/X VGND VGND VPWR VPWR _2208_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_26_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2139_ _2142_/CLK _2139_/D _1779_/X VGND VGND VPWR VPWR _2139_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_41_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1441_ _1441_/A _2160_/Q VGND VGND VPWR VPWR _1799_/S sky130_fd_sc_hd__nor2_4
XFILLER_4_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1510_ _2143_/Q VGND VGND VPWR VPWR _1510_/Y sky130_fd_sc_hd__inv_2
X_1372_ _2248_/Q _2247_/Q _1372_/C _1374_/D VGND VGND VPWR VPWR _1376_/C sky130_fd_sc_hd__or4_4
XFILLER_4_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1708_ _1107_/Y _1113_/A _1696_/X _1707_/Y _1684_/A VGND VGND VPWR VPWR _1709_/A
+ sky130_fd_sc_hd__o32a_1
X_1639_ _1960_/B _1672_/A VGND VGND VPWR VPWR _1639_/X sky130_fd_sc_hd__or2_1
XFILLER_13_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1990_ _1987_/Y _1988_/X _1602_/Y _1989_/X VGND VGND VPWR VPWR _1990_/X sky130_fd_sc_hd__o22a_1
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1355_ _1355_/A _2257_/Q _1355_/C _2258_/Q VGND VGND VPWR VPWR _1356_/B sky130_fd_sc_hd__or4b_4
X_1424_ _1449_/A VGND VGND VPWR VPWR _1424_/X sky130_fd_sc_hd__clkbuf_1
X_1286_ _1286_/A VGND VGND VPWR VPWR _1286_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_36_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1140_ _1145_/A VGND VGND VPWR VPWR _1140_/X sky130_fd_sc_hd__clkbuf_1
X_1071_ _1279_/A _1151_/A VGND VGND VPWR VPWR _1501_/A sky130_fd_sc_hd__or2_1
XFILLER_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1973_ _2139_/Q _2138_/Q _2047_/C _1972_/X VGND VGND VPWR VPWR _2189_/D sky130_fd_sc_hd__o211a_1
XFILLER_28_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1407_ _1406_/Y _1358_/A _1383_/Y _1348_/B _1361_/A VGND VGND VPWR VPWR _1408_/A
+ sky130_fd_sc_hd__o32a_1
X_1338_ _1375_/A _1338_/B _2243_/Q _2244_/Q VGND VGND VPWR VPWR _1338_/X sky130_fd_sc_hd__or4b_4
X_1269_ _1269_/A VGND VGND VPWR VPWR _2095_/S sky130_fd_sc_hd__buf_6
XPHY_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2172_ _2172_/CLK _2172_/D _1739_/X VGND VGND VPWR VPWR _2172_/Q sky130_fd_sc_hd__dfrtp_1
X_2310_ _2312_/CLK _2310_/D _1089_/X VGND VGND VPWR VPWR _2310_/Q sky130_fd_sc_hd__dfrtp_4
X_2241_ _2241_/CLK _2241_/D _1426_/X VGND VGND VPWR VPWR _2241_/Q sky130_fd_sc_hd__dfrtp_1
X_1123_ _1279_/A VGND VGND VPWR VPWR _1271_/A sky130_fd_sc_hd__clkbuf_2
X_1054_ _1524_/A VGND VGND VPWR VPWR _1078_/A sky130_fd_sc_hd__inv_2
XFILLER_21_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1956_ _2284_/Q VGND VGND VPWR VPWR _1956_/Y sky130_fd_sc_hd__inv_2
X_1887_ _2291_/Q VGND VGND VPWR VPWR _1887_/Y sky130_fd_sc_hd__inv_2
XFILLER_31_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput19 _2049_/LO VGND VGND VPWR VPWR scl_pad_o sky130_fd_sc_hd__clkbuf_2
XFILLER_56_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1741_ _1743_/A VGND VGND VPWR VPWR _1741_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_30_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1810_ _1818_/A VGND VGND VPWR VPWR _1810_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_15_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1672_ _1672_/A _1672_/B VGND VGND VPWR VPWR _1819_/B sky130_fd_sc_hd__or2_2
XFILLER_53_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1106_ _1131_/A VGND VGND VPWR VPWR _1106_/X sky130_fd_sc_hd__clkbuf_1
X_2155_ _2241_/CLK _2155_/D _1760_/X VGND VGND VPWR VPWR _2155_/Q sky130_fd_sc_hd__dfrtp_1
X_2224_ _2224_/CLK _2224_/D _1509_/X VGND VGND VPWR VPWR _2224_/Q sky130_fd_sc_hd__dfstp_1
X_2086_ _2223_/Q _2313_/Q _2153_/Q VGND VGND VPWR VPWR _2086_/X sky130_fd_sc_hd__mux2_1
XFILLER_21_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1939_ _1938_/Y _1936_/Y _1209_/B VGND VGND VPWR VPWR _1939_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_21_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1724_ _1725_/A VGND VGND VPWR VPWR _1724_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_7_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1586_ _1588_/A VGND VGND VPWR VPWR _1587_/A sky130_fd_sc_hd__inv_2
X_1655_ _1809_/B _1655_/B VGND VGND VPWR VPWR _1676_/B sky130_fd_sc_hd__or2_1
X_2069_ _1935_/X _2292_/Q _2180_/D VGND VGND VPWR VPWR _2069_/X sky130_fd_sc_hd__mux2_1
X_2207_ _2220_/CLK _2207_/D _1597_/X VGND VGND VPWR VPWR _2207_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_26_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2138_ _2142_/CLK _2138_/D _1780_/X VGND VGND VPWR VPWR _2138_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_1_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1440_ _2239_/Q VGND VGND VPWR VPWR _1440_/Y sky130_fd_sc_hd__inv_2
X_1371_ _2129_/Q VGND VGND VPWR VPWR _1371_/Y sky130_fd_sc_hd__inv_2
XFILLER_31_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1638_ _1627_/X _1638_/B _1638_/C _1638_/D VGND VGND VPWR VPWR _1672_/A sky130_fd_sc_hd__and4b_2
X_1707_ _2192_/Q VGND VGND VPWR VPWR _1707_/Y sky130_fd_sc_hd__inv_2
X_1569_ _2157_/Q _2156_/Q _1569_/C VGND VGND VPWR VPWR _1576_/A sky130_fd_sc_hd__or3_4
XFILLER_14_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1285_ _2263_/Q _1269_/A _2264_/Q _1270_/X _1280_/X VGND VGND VPWR VPWR _2264_/D
+ sky130_fd_sc_hd__a221o_1
X_1423_ _1530_/A VGND VGND VPWR VPWR _1449_/A sky130_fd_sc_hd__clkbuf_2
X_1354_ _1365_/A VGND VGND VPWR VPWR _1354_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_55_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_13_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2307_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_50_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1070_ _1070_/A VGND VGND VPWR VPWR _1151_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_37_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1972_ _1497_/X _1962_/B _1962_/B _2138_/Q VGND VGND VPWR VPWR _1972_/X sky130_fd_sc_hd__a22o_1
X_1268_ _1270_/A VGND VGND VPWR VPWR _1269_/A sky130_fd_sc_hd__inv_2
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1406_ _2130_/Q VGND VGND VPWR VPWR _1406_/Y sky130_fd_sc_hd__inv_2
X_1337_ _1337_/A _1337_/B _1337_/C _1337_/D VGND VGND VPWR VPWR _1337_/X sky130_fd_sc_hd__or4_4
X_1199_ _1220_/A VGND VGND VPWR VPWR _1199_/X sky130_fd_sc_hd__clkbuf_1
XPHY_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2171_ _2172_/CLK _2171_/D _1740_/X VGND VGND VPWR VPWR _2171_/Q sky130_fd_sc_hd__dfrtp_1
X_1122_ _1131_/A VGND VGND VPWR VPWR _1122_/X sky130_fd_sc_hd__clkbuf_1
X_2240_ _2267_/CLK _2240_/D _1435_/X VGND VGND VPWR VPWR _2240_/Q sky130_fd_sc_hd__dfstp_1
X_1955_ _2283_/Q _1954_/B _1954_/Y VGND VGND VPWR VPWR _1955_/X sky130_fd_sc_hd__a21o_1
X_1886_ _2042_/A _1886_/B _1886_/C _2161_/Q VGND VGND VPWR VPWR _2156_/D sky130_fd_sc_hd__and4_1
XFILLER_56_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1740_ _1743_/A VGND VGND VPWR VPWR _1740_/X sky130_fd_sc_hd__clkbuf_1
X_1671_ _1820_/A _1506_/Y _1497_/A _2202_/Q _2189_/Q VGND VGND VPWR VPWR _1672_/B
+ sky130_fd_sc_hd__a311o_1
X_2085_ _1902_/X _2297_/Q _2095_/S VGND VGND VPWR VPWR _2085_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1105_ _2048_/A VGND VGND VPWR VPWR _1131_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_38_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2223_ _2223_/CLK _2223_/D _1522_/X VGND VGND VPWR VPWR _2223_/Q sky130_fd_sc_hd__dfrtp_1
X_2154_ _2260_/CLK _2154_/D _1761_/X VGND VGND VPWR VPWR _2154_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_53_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1938_ _2274_/Q VGND VGND VPWR VPWR _1938_/Y sky130_fd_sc_hd__inv_2
X_1869_ _1885_/B VGND VGND VPWR VPWR _1896_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_29_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1723_ _1725_/A VGND VGND VPWR VPWR _1723_/X sky130_fd_sc_hd__clkbuf_1
X_1654_ _1672_/A VGND VGND VPWR VPWR _1655_/B sky130_fd_sc_hd__inv_2
X_2206_ _2220_/CLK _2206_/D _1599_/X VGND VGND VPWR VPWR _2206_/Q sky130_fd_sc_hd__dfstp_1
X_1585_ _1151_/A _1989_/A _1155_/A VGND VGND VPWR VPWR _1588_/A sky130_fd_sc_hd__o21ai_2
XFILLER_53_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2068_ _1934_/X _2291_/Q _2180_/D VGND VGND VPWR VPWR _2068_/X sky130_fd_sc_hd__mux2_1
XFILLER_41_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2137_ _2137_/CLK _2137_/D _1782_/X VGND VGND VPWR VPWR _2137_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_17_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1370_ _1390_/A VGND VGND VPWR VPWR _1370_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_23_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1637_ _1476_/Y _2206_/Q _2234_/Q _1633_/Y _1636_/X VGND VGND VPWR VPWR _1638_/D
+ sky130_fd_sc_hd__o221a_1
X_1706_ _1719_/A VGND VGND VPWR VPWR _1706_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_48_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1568_ _2137_/Q VGND VGND VPWR VPWR _1571_/A sky130_fd_sc_hd__inv_2
X_1499_ _1499_/A VGND VGND VPWR VPWR _2227_/D sky130_fd_sc_hd__inv_2
XFILLER_14_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1422_ _1744_/A VGND VGND VPWR VPWR _1530_/A sky130_fd_sc_hd__buf_1
X_1284_ _1286_/A VGND VGND VPWR VPWR _1284_/X sky130_fd_sc_hd__clkbuf_1
X_1353_ _2260_/Q _1351_/B _1357_/B _1352_/Y VGND VGND VPWR VPWR _2260_/D sky130_fd_sc_hd__a211o_1
XFILLER_51_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1971_ _1971_/A _1971_/B VGND VGND VPWR VPWR _2185_/D sky130_fd_sc_hd__nor2_1
X_1405_ _1405_/A VGND VGND VPWR VPWR _1405_/X sky130_fd_sc_hd__clkbuf_1
X_1267_ _2175_/Q _1267_/B VGND VGND VPWR VPWR _1270_/A sky130_fd_sc_hd__or2_2
Xinput1 arst_i VGND VGND VPWR VPWR input1/X sky130_fd_sc_hd__clkbuf_1
X_1336_ _1377_/A _2252_/Q _1330_/C VGND VGND VPWR VPWR _1337_/C sky130_fd_sc_hd__or3b_2
X_1198_ _2285_/Q _2189_/Q _2202_/Q _1195_/Y _1931_/A VGND VGND VPWR VPWR _2285_/D
+ sky130_fd_sc_hd__o221a_1
XFILLER_51_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2170_ _2172_/CLK _2170_/D _1741_/X VGND VGND VPWR VPWR _2170_/Q sky130_fd_sc_hd__dfrtp_1
X_1121_ _1121_/A VGND VGND VPWR VPWR _2305_/D sky130_fd_sc_hd__inv_2
X_1954_ _2283_/Q _1954_/B VGND VGND VPWR VPWR _1954_/Y sky130_fd_sc_hd__nor2_1
XFILLER_18_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1885_ _2161_/Q _1885_/B _2159_/Q _2042_/A VGND VGND VPWR VPWR _2157_/D sky130_fd_sc_hd__and4b_1
XFILLER_56_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2299_ _2313_/CLK _2299_/D _1143_/X VGND VGND VPWR VPWR _2299_/Q sky130_fd_sc_hd__dfstp_1
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1319_ _2253_/Q VGND VGND VPWR VPWR _1337_/B sky130_fd_sc_hd__buf_1
XFILLER_24_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1670_ _1670_/A VGND VGND VPWR VPWR _1670_/X sky130_fd_sc_hd__clkbuf_1
X_2222_ _2222_/CLK _2222_/D _1531_/X VGND VGND VPWR VPWR _2222_/Q sky130_fd_sc_hd__dfrtp_1
X_1104_ _1104_/A VGND VGND VPWR VPWR _2308_/D sky130_fd_sc_hd__inv_2
XFILLER_38_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2084_ _2150_/Q _2153_/Q _2140_/Q VGND VGND VPWR VPWR _2084_/X sky130_fd_sc_hd__mux2_1
X_2153_ _2262_/CLK _2153_/D _1762_/X VGND VGND VPWR VPWR _2153_/Q sky130_fd_sc_hd__dfrtp_2
X_1937_ _2273_/Q _1936_/B _1936_/Y VGND VGND VPWR VPWR _1937_/X sky130_fd_sc_hd__a21o_1
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1799_ _2122_/Q _2159_/Q _1799_/S VGND VGND VPWR VPWR _2122_/D sky130_fd_sc_hd__mux2_1
X_1868_ _2132_/Q _1655_/B _1672_/B _1580_/A _1867_/X VGND VGND VPWR VPWR _2132_/D
+ sky130_fd_sc_hd__a311o_1
XFILLER_29_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_8_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2234_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1584_ _1977_/A _1979_/B _1979_/C VGND VGND VPWR VPWR _1989_/A sky130_fd_sc_hd__or3_4
X_1722_ _1725_/A VGND VGND VPWR VPWR _1722_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_7_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1653_ _2133_/Q _2137_/Q _1653_/C VGND VGND VPWR VPWR _1653_/X sky130_fd_sc_hd__or3_1
X_2205_ _2289_/CLK _2205_/D _1601_/X VGND VGND VPWR VPWR _2205_/Q sky130_fd_sc_hd__dfrtp_1
X_2067_ _1933_/X _2290_/Q _2180_/D VGND VGND VPWR VPWR _2067_/X sky130_fd_sc_hd__mux2_1
XFILLER_34_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2136_ _2137_/CLK _2136_/D _1783_/X VGND VGND VPWR VPWR _2136_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_1_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1705_ _1738_/A VGND VGND VPWR VPWR _1719_/A sky130_fd_sc_hd__clkbuf_2
X_1636_ _2235_/Q _1634_/Y _2236_/Q _1635_/Y VGND VGND VPWR VPWR _1636_/X sky130_fd_sc_hd__o22a_1
X_1567_ _1594_/A VGND VGND VPWR VPWR _1567_/X sky130_fd_sc_hd__clkbuf_1
X_2119_ _2303_/CLK _2119_/D VGND VGND VPWR VPWR _2119_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_54_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1498_ _1084_/Y _1113_/X _1490_/Y _1497_/X _1490_/A VGND VGND VPWR VPWR _1499_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_22_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1421_ _1421_/A VGND VGND VPWR VPWR _2243_/D sky130_fd_sc_hd__inv_2
X_1283_ _2264_/Q _1269_/A _2265_/Q _1270_/X _1280_/X VGND VGND VPWR VPWR _2265_/D
+ sky130_fd_sc_hd__a221o_1
X_1352_ _1352_/A VGND VGND VPWR VPWR _1352_/Y sky130_fd_sc_hd__inv_2
XFILLER_51_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_22_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2223_/CLK sky130_fd_sc_hd__clkbuf_16
X_1619_ _1670_/A VGND VGND VPWR VPWR _1619_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_54_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1970_ _1187_/X _1575_/Y _1810_/X _1842_/D _1674_/B VGND VGND VPWR VPWR _1971_/B
+ sky130_fd_sc_hd__o221a_1
XFILLER_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1404_ _1349_/A _1391_/X _2249_/Q _1392_/X VGND VGND VPWR VPWR _2249_/D sky130_fd_sc_hd__a2bb2o_1
X_1335_ _1357_/B VGND VGND VPWR VPWR _1880_/B sky130_fd_sc_hd__inv_2
Xinput2 scl_pad_i VGND VGND VPWR VPWR input2/X sky130_fd_sc_hd__clkbuf_1
X_1266_ _2174_/Q _1266_/B VGND VGND VPWR VPWR _1267_/B sky130_fd_sc_hd__or2_1
XFILLER_36_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1197_ _1885_/B VGND VGND VPWR VPWR _1931_/A sky130_fd_sc_hd__buf_2
XPHY_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1120_ _1100_/X _1085_/A _1118_/Y _1119_/Y _1080_/A VGND VGND VPWR VPWR _1121_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_18_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1953_ _2282_/Q _1952_/B _1954_/B VGND VGND VPWR VPWR _1953_/X sky130_fd_sc_hd__a21bo_1
X_1884_ _1462_/A _2155_/Q _1896_/B _1879_/A VGND VGND VPWR VPWR _2155_/D sky130_fd_sc_hd__o211a_1
X_2298_ _2313_/CLK _2298_/D _1145_/X VGND VGND VPWR VPWR _2298_/Q sky130_fd_sc_hd__dfstp_1
X_1318_ _2259_/Q VGND VGND VPWR VPWR _1377_/A sky130_fd_sc_hd__clkbuf_2
X_1249_ _1257_/A VGND VGND VPWR VPWR _1249_/X sky130_fd_sc_hd__clkbuf_1
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2152_ _2241_/CLK _2152_/D _1764_/X VGND VGND VPWR VPWR _2182_/D sky130_fd_sc_hd__dfrtp_1
X_2221_ _2229_/CLK _2221_/D _1533_/X VGND VGND VPWR VPWR _2221_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1103_ _1100_/X _1085_/A _1101_/Y _1102_/Y _1080_/X VGND VGND VPWR VPWR _1104_/A
+ sky130_fd_sc_hd__o32a_1
X_2083_ _1965_/X _1961_/A _2083_/S VGND VGND VPWR VPWR _2083_/X sky130_fd_sc_hd__mux2_1
X_1936_ _2273_/Q _1936_/B VGND VGND VPWR VPWR _1936_/Y sky130_fd_sc_hd__nor2_1
X_1867_ _1497_/X _2153_/Q _2139_/Q _1866_/Y VGND VGND VPWR VPWR _1867_/X sky130_fd_sc_hd__a31o_1
XFILLER_21_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1798_ _1798_/A VGND VGND VPWR VPWR _1798_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_16_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1721_ _1725_/A VGND VGND VPWR VPWR _1721_/X sky130_fd_sc_hd__clkbuf_1
X_1583_ _1594_/A VGND VGND VPWR VPWR _1583_/X sky130_fd_sc_hd__clkbuf_1
X_1652_ _2135_/Q _2136_/Q VGND VGND VPWR VPWR _1653_/C sky130_fd_sc_hd__or2_1
X_2135_ _2137_/CLK _2135_/D _1784_/X VGND VGND VPWR VPWR _2135_/Q sky130_fd_sc_hd__dfrtp_1
X_2204_ _2223_/CLK _2204_/D _1605_/X VGND VGND VPWR VPWR _2204_/Q sky130_fd_sc_hd__dfrtp_1
X_2066_ _1932_/Y _2289_/Q _2180_/D VGND VGND VPWR VPWR _2066_/X sky130_fd_sc_hd__mux2_1
XFILLER_34_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1919_ _2172_/Q _1912_/X _2173_/Q VGND VGND VPWR VPWR _1920_/A sky130_fd_sc_hd__o21a_1
XFILLER_27_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1704_ _1744_/A VGND VGND VPWR VPWR _1738_/A sky130_fd_sc_hd__clkbuf_2
X_1635_ _2211_/Q VGND VGND VPWR VPWR _1635_/Y sky130_fd_sc_hd__inv_2
X_1566_ _1678_/A VGND VGND VPWR VPWR _1594_/A sky130_fd_sc_hd__clkbuf_2
X_1497_ _1497_/A VGND VGND VPWR VPWR _1497_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_54_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2049_ VGND VGND VPWR VPWR _2049_/HI _2049_/LO sky130_fd_sc_hd__conb_1
X_2118_ _2137_/CLK _2118_/D VGND VGND VPWR VPWR _2118_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1420_ _1419_/Y _1358_/A _1383_/Y _1326_/C _1361_/A VGND VGND VPWR VPWR _1421_/A
+ sky130_fd_sc_hd__o32a_1
X_1351_ _1381_/A _1351_/B _1351_/C _1379_/B VGND VGND VPWR VPWR _1352_/A sky130_fd_sc_hd__or4b_4
X_1282_ _1286_/A VGND VGND VPWR VPWR _1282_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_36_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1618_ _1678_/A VGND VGND VPWR VPWR _1670_/A sky130_fd_sc_hd__buf_1
X_1549_ _2214_/Q _2213_/Q _2215_/Q VGND VGND VPWR VPWR _1553_/B sky130_fd_sc_hd__o21a_1
XFILLER_54_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1265_ _2171_/Q _2170_/Q _1265_/C _1912_/C VGND VGND VPWR VPWR _1266_/B sky130_fd_sc_hd__or4_4
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1403_ _1405_/A VGND VGND VPWR VPWR _1403_/X sky130_fd_sc_hd__clkbuf_1
X_1334_ _1334_/A VGND VGND VPWR VPWR _1334_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_36_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1196_ _1540_/A VGND VGND VPWR VPWR _1885_/B sky130_fd_sc_hd__buf_1
XFILLER_24_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput3 sda_pad_i VGND VGND VPWR VPWR input3/X sky130_fd_sc_hd__clkbuf_2
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1952_ _2282_/Q _1952_/B VGND VGND VPWR VPWR _1954_/B sky130_fd_sc_hd__or2_1
XFILLER_33_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1883_ _1881_/X _1882_/X _1930_/A VGND VGND VPWR VPWR _2154_/D sky130_fd_sc_hd__o21a_1
XFILLER_56_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1248_ _1248_/A VGND VGND VPWR VPWR _1257_/A sky130_fd_sc_hd__clkbuf_2
X_2297_ _2313_/CLK _2297_/D _1148_/X VGND VGND VPWR VPWR _2297_/Q sky130_fd_sc_hd__dfstp_1
X_1317_ _2251_/Q VGND VGND VPWR VPWR _1330_/C sky130_fd_sc_hd__buf_1
X_1179_ _1179_/A VGND VGND VPWR VPWR _1179_/X sky130_fd_sc_hd__clkbuf_1
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1102_ _2308_/Q VGND VGND VPWR VPWR _1102_/Y sky130_fd_sc_hd__inv_2
XFILLER_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2220_ _2220_/CLK _2220_/D _1535_/X VGND VGND VPWR VPWR _2220_/Q sky130_fd_sc_hd__dfrtp_1
X_2082_ _1961_/A _1961_/X _2150_/Q VGND VGND VPWR VPWR _2082_/X sky130_fd_sc_hd__mux2_1
X_2151_ _2224_/CLK _2151_/D _1765_/X VGND VGND VPWR VPWR _2151_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_53_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1935_ _2272_/Q _1207_/B _1936_/B VGND VGND VPWR VPWR _1935_/X sky130_fd_sc_hd__a21bo_1
X_1797_ _1798_/A VGND VGND VPWR VPWR _1797_/X sky130_fd_sc_hd__clkbuf_1
X_1866_ _1810_/X _1842_/B _1621_/A VGND VGND VPWR VPWR _1866_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1651_ _1851_/A _1851_/B _1667_/C _1650_/X VGND VGND VPWR VPWR _1651_/X sky130_fd_sc_hd__o31a_1
X_1720_ _1738_/A VGND VGND VPWR VPWR _1725_/A sky130_fd_sc_hd__buf_1
XFILLER_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1582_ _1579_/B _1580_/X _2212_/Q _1581_/Y VGND VGND VPWR VPWR _2212_/D sky130_fd_sc_hd__o22a_1
X_2065_ _1957_/Y _2304_/Q _2180_/D VGND VGND VPWR VPWR _2065_/X sky130_fd_sc_hd__mux2_1
XFILLER_26_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2203_ _2223_/CLK _2203_/D _1611_/X VGND VGND VPWR VPWR _2203_/Q sky130_fd_sc_hd__dfrtp_1
X_2134_ _2287_/CLK _2134_/D _1785_/X VGND VGND VPWR VPWR _2134_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_16_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2289_/CLK sky130_fd_sc_hd__clkbuf_16
X_1918_ _2302_/Q VGND VGND VPWR VPWR _1918_/Y sky130_fd_sc_hd__inv_2
X_1849_ _1971_/A _1675_/A _1419_/Y _1848_/Y VGND VGND VPWR VPWR _2131_/D sky130_fd_sc_hd__o22ai_1
XFILLER_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1634_ _2210_/Q VGND VGND VPWR VPWR _1634_/Y sky130_fd_sc_hd__inv_2
X_1703_ _1703_/A VGND VGND VPWR VPWR _2193_/D sky130_fd_sc_hd__inv_2
X_1565_ _1565_/A VGND VGND VPWR VPWR _2213_/D sky130_fd_sc_hd__inv_2
X_1496_ _2227_/Q VGND VGND VPWR VPWR _1497_/A sky130_fd_sc_hd__inv_2
X_2048_ _2048_/A VGND VGND VPWR VPWR _2048_/X sky130_fd_sc_hd__clkbuf_1
X_2117_ _2137_/CLK _2117_/D VGND VGND VPWR VPWR _2117_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1281_ _2179_/Q _2095_/S _2266_/Q _1270_/X _1280_/X VGND VGND VPWR VPWR _2266_/D
+ sky130_fd_sc_hd__a221o_1
X_1350_ _1381_/B _1380_/B _1332_/D VGND VGND VPWR VPWR _1351_/C sky130_fd_sc_hd__or3b_1
XFILLER_36_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1617_ _2203_/Q _1574_/C _1617_/S VGND VGND VPWR VPWR _2203_/D sky130_fd_sc_hd__mux2_1
X_1479_ _2230_/Q VGND VGND VPWR VPWR _1479_/Y sky130_fd_sc_hd__inv_2
X_1548_ _1562_/A VGND VGND VPWR VPWR _1548_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_42_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1402_ _1391_/A _1378_/C _2250_/Q _1392_/X VGND VGND VPWR VPWR _2250_/D sky130_fd_sc_hd__a2bb2o_1
XFILLER_5_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput4 wb_adr_i[0] VGND VGND VPWR VPWR input4/X sky130_fd_sc_hd__clkbuf_2
X_1264_ _2169_/Q _1264_/B VGND VGND VPWR VPWR _1912_/C sky130_fd_sc_hd__or2_2
X_1333_ _2256_/Q _1333_/B _1355_/C _2255_/Q VGND VGND VPWR VPWR _1334_/A sky130_fd_sc_hd__or4b_4
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1195_ _2189_/Q VGND VGND VPWR VPWR _1195_/Y sky130_fd_sc_hd__inv_2
XFILLER_10_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1951_ _2281_/Q _1950_/B _1952_/B VGND VGND VPWR VPWR _1951_/X sky130_fd_sc_hd__a21bo_1
X_1882_ _2262_/Q _2157_/Q _1882_/C VGND VGND VPWR VPWR _1882_/X sky130_fd_sc_hd__and3b_1
XFILLER_56_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1247_ _2070_/X _1243_/X _2273_/Q _1244_/X VGND VGND VPWR VPWR _2273_/D sky130_fd_sc_hd__a22o_1
X_2296_ _2313_/CLK _2296_/D _1150_/X VGND VGND VPWR VPWR _2296_/Q sky130_fd_sc_hd__dfstp_1
X_1178_ _1175_/X input8/X _1155_/B _2289_/Q _1160_/A VGND VGND VPWR VPWR _2289_/D
+ sky130_fd_sc_hd__o32a_1
X_1316_ _1379_/A _1379_/B _2081_/X _1520_/B VGND VGND VPWR VPWR _1316_/X sky130_fd_sc_hd__a31o_1
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1101_ _1540_/A _1101_/B VGND VGND VPWR VPWR _1101_/Y sky130_fd_sc_hd__nand2_1
XFILLER_23_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_2081_ _1356_/B _1306_/B _2259_/Q VGND VGND VPWR VPWR _2081_/X sky130_fd_sc_hd__mux2_1
X_2150_ _2261_/CLK _2150_/D _1766_/X VGND VGND VPWR VPWR _2150_/Q sky130_fd_sc_hd__dfrtp_2
X_1934_ _2271_/Q _1206_/B _1207_/B VGND VGND VPWR VPWR _1934_/X sky130_fd_sc_hd__a21bo_1
X_1796_ _1798_/A VGND VGND VPWR VPWR _1796_/X sky130_fd_sc_hd__clkbuf_1
X_1865_ _1187_/X _2134_/Q _1621_/A _1573_/A _2188_/D VGND VGND VPWR VPWR _2134_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_29_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2279_ _2295_/CLK _2279_/D _1229_/X VGND VGND VPWR VPWR _2279_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_37_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1650_ _1666_/B _1667_/B _1665_/A _2229_/Q _1664_/B VGND VGND VPWR VPWR _1650_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1581_ _2229_/Q _1573_/A _1580_/X VGND VGND VPWR VPWR _1581_/Y sky130_fd_sc_hd__a21oi_1
X_2202_ _2223_/CLK _2202_/D _1619_/X VGND VGND VPWR VPWR _2202_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2064_ _1955_/X _2303_/Q _2180_/D VGND VGND VPWR VPWR _2064_/X sky130_fd_sc_hd__mux2_1
XFILLER_34_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2133_ _2142_/CLK _2133_/D _1786_/X VGND VGND VPWR VPWR _2133_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_19_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1917_ _2089_/X _1921_/B VGND VGND VPWR VPWR _2172_/D sky130_fd_sc_hd__nor2_1
X_1779_ _1780_/A VGND VGND VPWR VPWR _1779_/X sky130_fd_sc_hd__clkbuf_1
X_1848_ _1848_/A _1854_/A VGND VGND VPWR VPWR _1848_/Y sky130_fd_sc_hd__nor2_2
XFILLER_48_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1633_ _2209_/Q VGND VGND VPWR VPWR _1633_/Y sky130_fd_sc_hd__inv_2
X_1702_ _1100_/X _1696_/X _1101_/Y _1701_/Y _1684_/X VGND VGND VPWR VPWR _1703_/A
+ sky130_fd_sc_hd__o32a_1
X_1564_ _1271_/A _1554_/Y _1563_/Y _1563_/A _1554_/A VGND VGND VPWR VPWR _1565_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_39_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1495_ _1522_/A VGND VGND VPWR VPWR _1495_/X sky130_fd_sc_hd__clkbuf_1
X_2116_ _2267_/CLK _2116_/D VGND VGND VPWR VPWR _2116_/Q sky130_fd_sc_hd__dfxtp_1
X_2047_ _2287_/Q _2134_/Q _2047_/C VGND VGND VPWR VPWR _2133_/D sky130_fd_sc_hd__and3_1
XFILLER_13_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_1_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2260_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_48_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1280_ _1280_/A VGND VGND VPWR VPWR _1280_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_48_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1616_ _1818_/D _1613_/X _1805_/A _1579_/Y VGND VGND VPWR VPWR _1617_/S sky130_fd_sc_hd__o211a_1
X_1547_ _1886_/B _1527_/A _2097_/X _2216_/Q _1528_/A VGND VGND VPWR VPWR _2216_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_54_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1478_ _1487_/A VGND VGND VPWR VPWR _1478_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_24_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1401_ _1405_/A VGND VGND VPWR VPWR _1401_/X sky130_fd_sc_hd__clkbuf_1
Xinput5 wb_adr_i[1] VGND VGND VPWR VPWR input5/X sky130_fd_sc_hd__buf_2
X_1263_ _2168_/Q _1263_/B VGND VGND VPWR VPWR _1264_/B sky130_fd_sc_hd__or2_1
XFILLER_36_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1332_ _1332_/A _1343_/B _1332_/C _1332_/D VGND VGND VPWR VPWR _1332_/X sky130_fd_sc_hd__and4_1
X_1194_ _1220_/A VGND VGND VPWR VPWR _1194_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_51_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1950_ _2281_/Q _1950_/B VGND VGND VPWR VPWR _1952_/B sky130_fd_sc_hd__or2_1
XFILLER_18_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1881_ _2242_/Q _1886_/C _2052_/X VGND VGND VPWR VPWR _1881_/X sky130_fd_sc_hd__and3_1
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1315_ _2187_/Q VGND VGND VPWR VPWR _1520_/B sky130_fd_sc_hd__inv_2
X_1246_ _1246_/A VGND VGND VPWR VPWR _1246_/X sky130_fd_sc_hd__clkbuf_1
X_2295_ _2295_/CLK _2295_/D _1158_/X VGND VGND VPWR VPWR _2295_/Q sky130_fd_sc_hd__dfstp_1
X_1177_ _1179_/A VGND VGND VPWR VPWR _1177_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_2_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2080_ _1900_/X _2296_/Q _2095_/S VGND VGND VPWR VPWR _2080_/X sky130_fd_sc_hd__mux2_1
XFILLER_46_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1100_ _1181_/B VGND VGND VPWR VPWR _1100_/X sky130_fd_sc_hd__clkbuf_2
X_1933_ _2270_/Q _2269_/Q _1206_/B VGND VGND VPWR VPWR _1933_/X sky130_fd_sc_hd__a21bo_1
X_1795_ _1798_/A VGND VGND VPWR VPWR _1795_/X sky130_fd_sc_hd__clkbuf_1
X_1864_ _1975_/B _1864_/B VGND VGND VPWR VPWR _2135_/D sky130_fd_sc_hd__nor2_1
X_2278_ _2295_/CLK _2278_/D _1233_/X VGND VGND VPWR VPWR _2278_/Q sky130_fd_sc_hd__dfrtp_1
X_1229_ _1233_/A VGND VGND VPWR VPWR _1229_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_52_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1580_ _1580_/A _1580_/B _1579_/Y VGND VGND VPWR VPWR _1580_/X sky130_fd_sc_hd__or3b_4
X_2201_ _2223_/CLK _2201_/D _1641_/X VGND VGND VPWR VPWR _2201_/Q sky130_fd_sc_hd__dfrtp_1
X_2132_ _2286_/CLK _2132_/D _1788_/X VGND VGND VPWR VPWR _2132_/Q sky130_fd_sc_hd__dfstp_1
X_2063_ _1890_/X _2292_/Q _2095_/S VGND VGND VPWR VPWR _2063_/X sky130_fd_sc_hd__mux2_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1916_ _2172_/Q _1912_/X _2172_/Q _1912_/X VGND VGND VPWR VPWR _1916_/Y sky130_fd_sc_hd__a2bb2oi_1
X_1847_ _1818_/A _2142_/Q _1620_/A _1846_/X VGND VGND VPWR VPWR _1854_/A sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_25_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2250_/CLK sky130_fd_sc_hd__clkbuf_16
X_1778_ _1780_/A VGND VGND VPWR VPWR _1778_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1701_ _2193_/Q VGND VGND VPWR VPWR _1701_/Y sky130_fd_sc_hd__inv_2
X_1632_ _2231_/Q _1630_/Y _1466_/Y _2209_/Q _1631_/X VGND VGND VPWR VPWR _1638_/C
+ sky130_fd_sc_hd__o221a_1
X_1563_ _1563_/A _2185_/Q VGND VGND VPWR VPWR _1563_/Y sky130_fd_sc_hd__nor2_1
X_1494_ _1530_/A VGND VGND VPWR VPWR _1522_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_54_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2115_ _2268_/CLK _2115_/D VGND VGND VPWR VPWR _2115_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2046_ _2265_/Q _2264_/Q _2263_/Q _2045_/X _1124_/X VGND VGND VPWR VPWR _2158_/D
+ sky130_fd_sc_hd__a221o_1
XFILLER_22_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1477_ _1472_/Y _1460_/X _1476_/Y _1463_/X VGND VGND VPWR VPWR _2232_/D sky130_fd_sc_hd__o22ai_1
X_1615_ _2153_/Q _1842_/A _1818_/D VGND VGND VPWR VPWR _1805_/A sky130_fd_sc_hd__or3_4
X_1546_ _1562_/A VGND VGND VPWR VPWR _1546_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_54_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2029_ _1086_/Y _1976_/A _2024_/X _2027_/X _2028_/X VGND VGND VPWR VPWR _2029_/Y
+ sky130_fd_sc_hd__o2111ai_2
XFILLER_10_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1400_ _1391_/X _1378_/A _1330_/C _1392_/X VGND VGND VPWR VPWR _2251_/D sky130_fd_sc_hd__a2bb2o_1
X_1331_ _1337_/A _1337_/B _1331_/C _1337_/D VGND VGND VPWR VPWR _1332_/D sky130_fd_sc_hd__or4_4
X_1262_ _2167_/Q _2166_/Q _1897_/B VGND VGND VPWR VPWR _1263_/B sky130_fd_sc_hd__or3_1
XFILLER_36_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1193_ _1193_/A VGND VGND VPWR VPWR _2286_/D sky130_fd_sc_hd__inv_2
Xinput6 wb_adr_i[2] VGND VGND VPWR VPWR input6/X sky130_fd_sc_hd__buf_2
XFILLER_51_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1529_ _1523_/X _1527_/X _2111_/X _2223_/Q _1528_/X VGND VGND VPWR VPWR _2223_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_19_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1880_ _2180_/Q _1880_/B _1880_/C VGND VGND VPWR VPWR _2153_/D sky130_fd_sc_hd__and3_1
X_2294_ _2295_/CLK _2294_/D _1163_/X VGND VGND VPWR VPWR _2294_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1314_ _2255_/Q _1314_/B _1355_/C _1333_/B VGND VGND VPWR VPWR _1379_/B sky130_fd_sc_hd__or4_4
X_1245_ _2071_/X _1243_/X _2274_/Q _1244_/X VGND VGND VPWR VPWR _2274_/D sky130_fd_sc_hd__a22o_1
X_1176_ _1175_/X input9/X _1161_/A _2290_/Q _1160_/A VGND VGND VPWR VPWR _2290_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_20_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1932_ _2269_/Q VGND VGND VPWR VPWR _1932_/Y sky130_fd_sc_hd__inv_2
X_1863_ _2229_/Q _1664_/B _1960_/C _1851_/Y VGND VGND VPWR VPWR _1864_/B sky130_fd_sc_hd__o22a_1
XFILLER_14_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1794_ _1798_/A VGND VGND VPWR VPWR _1794_/X sky130_fd_sc_hd__clkbuf_1
X_2277_ _2295_/CLK _2277_/D _1236_/X VGND VGND VPWR VPWR _2277_/Q sky130_fd_sc_hd__dfrtp_1
X_1228_ _2077_/X _1216_/X _2280_/Q _1218_/X VGND VGND VPWR VPWR _2280_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1159_ _1271_/A VGND VGND VPWR VPWR _1159_/X sky130_fd_sc_hd__buf_1
XFILLER_16_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2062_ _1895_/X _2294_/Q _2095_/S VGND VGND VPWR VPWR _2062_/X sky130_fd_sc_hd__mux2_1
X_2200_ _2250_/CLK _2200_/D _1643_/X VGND VGND VPWR VPWR _2200_/Q sky130_fd_sc_hd__dfrtp_1
X_2131_ _2250_/CLK _2131_/D _1789_/X VGND VGND VPWR VPWR _2131_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_19_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1915_ _2301_/Q VGND VGND VPWR VPWR _1915_/Y sky130_fd_sc_hd__inv_2
X_1777_ _1780_/A VGND VGND VPWR VPWR _1777_/X sky130_fd_sc_hd__clkbuf_1
X_1846_ _1807_/A _2141_/Q _1807_/C _1814_/A VGND VGND VPWR VPWR _1846_/X sky130_fd_sc_hd__a31o_1
XFILLER_8_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1631_ _1631_/A _2211_/Q VGND VGND VPWR VPWR _1631_/X sky130_fd_sc_hd__or2_1
XPHY_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1700_ _1700_/A VGND VGND VPWR VPWR _1700_/X sky130_fd_sc_hd__clkbuf_1
X_1562_ _1562_/A VGND VGND VPWR VPWR _1562_/X sky130_fd_sc_hd__clkbuf_1
X_1493_ _1493_/A VGND VGND VPWR VPWR _2228_/D sky130_fd_sc_hd__inv_2
X_2114_ _2307_/CLK _2114_/D VGND VGND VPWR VPWR _2114_/Q sky130_fd_sc_hd__dfxtp_1
X_2045_ _2265_/Q _2264_/Q VGND VGND VPWR VPWR _2045_/X sky130_fd_sc_hd__or2_1
XFILLER_39_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1829_ _1829_/A VGND VGND VPWR VPWR _1829_/Y sky130_fd_sc_hd__inv_2
XFILLER_1_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1614_ _2139_/Q VGND VGND VPWR VPWR _1842_/A sky130_fd_sc_hd__inv_2
X_1476_ _2231_/Q VGND VGND VPWR VPWR _1476_/Y sky130_fd_sc_hd__inv_2
X_1545_ _1886_/B _1527_/A _2099_/X _2217_/Q _1528_/A VGND VGND VPWR VPWR _2217_/D
+ sky130_fd_sc_hd__a32o_1
X_2028_ _1922_/Y _1988_/A _1635_/Y _1989_/A VGND VGND VPWR VPWR _2028_/X sky130_fd_sc_hd__o22a_1
XFILLER_49_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1261_ _2165_/Q _1261_/B VGND VGND VPWR VPWR _1897_/B sky130_fd_sc_hd__or2_1
XFILLER_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1330_ _1330_/A _1330_/B _1330_/C VGND VGND VPWR VPWR _1331_/C sky130_fd_sc_hd__or3_1
Xinput7 wb_cyc_i VGND VGND VPWR VPWR input7/X sky130_fd_sc_hd__clkbuf_2
XFILLER_51_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1192_ _1100_/X _1061_/X _1118_/Y _1191_/Y _1181_/X VGND VGND VPWR VPWR _1193_/A
+ sky130_fd_sc_hd__o32a_1
X_1459_ _2156_/Q _1459_/B VGND VGND VPWR VPWR _1460_/A sky130_fd_sc_hd__or2_2
XFILLER_27_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1528_ _1528_/A VGND VGND VPWR VPWR _1528_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_42_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2293_ _2293_/CLK _2293_/D _1165_/X VGND VGND VPWR VPWR _2293_/Q sky130_fd_sc_hd__dfstp_1
X_1244_ _1244_/A VGND VGND VPWR VPWR _1244_/X sky130_fd_sc_hd__clkbuf_2
X_1313_ _2258_/Q _2257_/Q _1313_/C VGND VGND VPWR VPWR _1333_/B sky130_fd_sc_hd__or3_1
X_1175_ _1279_/A VGND VGND VPWR VPWR _1175_/X sky130_fd_sc_hd__clkbuf_2
Xclkbuf_leaf_19_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2287_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_32_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput10 wb_dat_i[2] VGND VGND VPWR VPWR _1107_/A sky130_fd_sc_hd__clkbuf_2
X_1862_ _1975_/B _1862_/B VGND VGND VPWR VPWR _2136_/D sky130_fd_sc_hd__nor2_1
X_1931_ _1931_/A _2176_/Q VGND VGND VPWR VPWR _2177_/D sky130_fd_sc_hd__and2_1
X_1793_ _1793_/A VGND VGND VPWR VPWR _1798_/A sky130_fd_sc_hd__clkbuf_2
X_2276_ _2295_/CLK _2276_/D _1238_/X VGND VGND VPWR VPWR _2276_/Q sky130_fd_sc_hd__dfrtp_1
X_1227_ _1233_/A VGND VGND VPWR VPWR _1227_/X sky130_fd_sc_hd__clkbuf_1
X_1158_ _1165_/A VGND VGND VPWR VPWR _1158_/X sky130_fd_sc_hd__clkbuf_1
X_1089_ _1099_/A VGND VGND VPWR VPWR _1089_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_4_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2061_ _1893_/X _2293_/Q _2095_/S VGND VGND VPWR VPWR _2061_/X sky130_fd_sc_hd__mux2_1
X_2130_ _2250_/CLK _2130_/D _1790_/X VGND VGND VPWR VPWR _2130_/Q sky130_fd_sc_hd__dfrtp_1
X_1914_ _2088_/X _1921_/B VGND VGND VPWR VPWR _2171_/D sky130_fd_sc_hd__nor2_1
X_1776_ _1780_/A VGND VGND VPWR VPWR _1776_/X sky130_fd_sc_hd__clkbuf_1
X_1845_ _2132_/Q _1620_/A _1819_/B _1844_/X VGND VGND VPWR VPWR _1848_/A sky130_fd_sc_hd__a31o_1
XFILLER_27_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2259_ _2261_/CLK _2259_/D _1354_/X VGND VGND VPWR VPWR _2259_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_43_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1630_ _2206_/Q VGND VGND VPWR VPWR _1630_/Y sky130_fd_sc_hd__inv_2
XPHY_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1492_ _1068_/Y _1113_/X _1490_/Y _1674_/A _1490_/A VGND VGND VPWR VPWR _1493_/A
+ sky130_fd_sc_hd__o32a_1
X_1561_ _1561_/A VGND VGND VPWR VPWR _2214_/D sky130_fd_sc_hd__inv_2
X_2044_ _2268_/Q _2267_/Q _2266_/Q _2043_/X _1280_/X VGND VGND VPWR VPWR _2159_/D
+ sky130_fd_sc_hd__a221o_1
X_2113_ _2254_/CLK _2113_/D VGND VGND VPWR VPWR _2113_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1828_ _2158_/Q VGND VGND VPWR VPWR _2042_/A sky130_fd_sc_hd__clkbuf_2
X_1759_ _1762_/A VGND VGND VPWR VPWR _1759_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_9_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1613_ _2139_/Q _2137_/Q VGND VGND VPWR VPWR _1613_/X sky130_fd_sc_hd__or2_1
XFILLER_8_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1544_ _1562_/A VGND VGND VPWR VPWR _1544_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_39_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1475_ _1487_/A VGND VGND VPWR VPWR _1475_/X sky130_fd_sc_hd__clkbuf_1
X_2027_ _2025_/Y _1983_/A _2026_/Y _1681_/X VGND VGND VPWR VPWR _2027_/X sky130_fd_sc_hd__o22a_1
XFILLER_33_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 wb_dat_i[0] VGND VGND VPWR VPWR input8/X sky130_fd_sc_hd__buf_2
X_1260_ _2164_/Q _1260_/B VGND VGND VPWR VPWR _1261_/B sky130_fd_sc_hd__or2_1
X_1191_ _2286_/Q VGND VGND VPWR VPWR _1191_/Y sky130_fd_sc_hd__inv_2
XFILLER_51_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1527_ _1527_/A VGND VGND VPWR VPWR _1527_/X sky130_fd_sc_hd__clkbuf_2
X_1458_ _2236_/Q VGND VGND VPWR VPWR _1631_/A sky130_fd_sc_hd__inv_2
XFILLER_27_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1389_ _1332_/C _1359_/X _1337_/A _1363_/X VGND VGND VPWR VPWR _2254_/D sky130_fd_sc_hd__a2bb2o_1
XFILLER_51_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1174_ _1179_/A VGND VGND VPWR VPWR _1174_/X sky130_fd_sc_hd__clkbuf_1
X_1243_ _1243_/A VGND VGND VPWR VPWR _1243_/X sky130_fd_sc_hd__clkbuf_2
X_2292_ _2293_/CLK _2292_/D _1170_/X VGND VGND VPWR VPWR _2292_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_2_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1312_ _1330_/A _1312_/B VGND VGND VPWR VPWR _1314_/B sky130_fd_sc_hd__or2_1
XFILLER_55_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1930_ _1930_/A input2/X VGND VGND VPWR VPWR _2176_/D sky130_fd_sc_hd__and2_1
XFILLER_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput11 wb_dat_i[3] VGND VGND VPWR VPWR _1101_/B sky130_fd_sc_hd__buf_2
X_1861_ _1667_/C _1851_/Y _1664_/X VGND VGND VPWR VPWR _1862_/B sky130_fd_sc_hd__o21a_1
X_1792_ _1792_/A VGND VGND VPWR VPWR _1792_/X sky130_fd_sc_hd__clkbuf_1
X_2275_ _2293_/CLK _2275_/D _1240_/X VGND VGND VPWR VPWR _2275_/Q sky130_fd_sc_hd__dfrtp_1
X_1226_ _2079_/X _1216_/X _2281_/Q _1218_/X VGND VGND VPWR VPWR _2281_/D sky130_fd_sc_hd__a22o_1
XFILLER_52_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1157_ _1141_/X _1068_/A _1155_/B _2296_/Q _1156_/X VGND VGND VPWR VPWR _2296_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_37_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1088_ _1088_/A VGND VGND VPWR VPWR _2311_/D sky130_fd_sc_hd__inv_2
XFILLER_20_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_4_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2268_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_47_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2060_ _2033_/Y _2296_/Q _2060_/S VGND VGND VPWR VPWR _2119_/D sky130_fd_sc_hd__mux2_1
XFILLER_34_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1913_ _1911_/Y _1907_/Y _1912_/X VGND VGND VPWR VPWR _1913_/X sky130_fd_sc_hd__o21a_1
X_1775_ _1793_/A VGND VGND VPWR VPWR _1780_/A sky130_fd_sc_hd__buf_1
XFILLER_8_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1844_ _1960_/D _1960_/B _1842_/X _1620_/A _1843_/X VGND VGND VPWR VPWR _1844_/X
+ sky130_fd_sc_hd__a41o_1
X_2258_ _2261_/CLK _2258_/D _1365_/X VGND VGND VPWR VPWR _2258_/Q sky130_fd_sc_hd__dfrtp_1
X_1209_ _2275_/Q _1209_/B VGND VGND VPWR VPWR _1210_/B sky130_fd_sc_hd__or2_1
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2189_ _2287_/CLK _2189_/D _1718_/X VGND VGND VPWR VPWR _2189_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_4_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1560_ _1280_/A _1554_/Y _1559_/Y _1557_/Y _1554_/A VGND VGND VPWR VPWR _1561_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_3_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2112_ _2142_/CLK _2112_/D VGND VGND VPWR VPWR _2112_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1491_ _2228_/Q VGND VGND VPWR VPWR _1674_/A sky130_fd_sc_hd__inv_2
XFILLER_54_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2043_ _2268_/Q _2267_/Q VGND VGND VPWR VPWR _2043_/X sky130_fd_sc_hd__or2_1
X_1827_ _1962_/B _1842_/B _1860_/A _1826_/X VGND VGND VPWR VPWR _2138_/D sky130_fd_sc_hd__o31ai_1
X_1689_ _1084_/Y _1501_/X _1681_/X _1688_/Y _1684_/X VGND VGND VPWR VPWR _1690_/A
+ sky130_fd_sc_hd__o32a_1
X_1758_ _1762_/A VGND VGND VPWR VPWR _1758_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_54_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1612_ _1819_/A VGND VGND VPWR VPWR _1818_/D sky130_fd_sc_hd__buf_1
X_1543_ _1678_/A VGND VGND VPWR VPWR _1562_/A sky130_fd_sc_hd__buf_1
X_1474_ _1530_/A VGND VGND VPWR VPWR _1487_/A sky130_fd_sc_hd__buf_1
XFILLER_54_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2026_ _2222_/Q VGND VGND VPWR VPWR _2026_/Y sky130_fd_sc_hd__inv_2
XFILLER_40_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput9 wb_dat_i[1] VGND VGND VPWR VPWR input9/X sky130_fd_sc_hd__buf_2
X_1190_ _1220_/A VGND VGND VPWR VPWR _1190_/X sky130_fd_sc_hd__clkbuf_1
X_1457_ _1471_/A VGND VGND VPWR VPWR _1457_/X sky130_fd_sc_hd__clkbuf_1
X_1526_ _1528_/A VGND VGND VPWR VPWR _1527_/A sky130_fd_sc_hd__inv_2
XFILLER_27_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1388_ _1390_/A VGND VGND VPWR VPWR _1388_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_19_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2009_ _2007_/Y _1983_/X _2008_/Y _1985_/X VGND VGND VPWR VPWR _2009_/X sky130_fd_sc_hd__o22a_1
XFILLER_2_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2291_ _2293_/CLK _2291_/D _1172_/X VGND VGND VPWR VPWR _2291_/Q sky130_fd_sc_hd__dfstp_1
X_1311_ _2256_/Q VGND VGND VPWR VPWR _1312_/B sky130_fd_sc_hd__inv_2
X_1242_ _1246_/A VGND VGND VPWR VPWR _1242_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_49_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1173_ _1159_/X _1107_/A _1161_/X _2291_/Q _1160_/A VGND VGND VPWR VPWR _2291_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_17_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1509_ _1522_/A VGND VGND VPWR VPWR _1509_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_55_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1860_ _1860_/A VGND VGND VPWR VPWR _1975_/B sky130_fd_sc_hd__clkbuf_2
X_1791_ _1792_/A VGND VGND VPWR VPWR _1791_/X sky130_fd_sc_hd__clkbuf_1
Xinput12 wb_dat_i[4] VGND VGND VPWR VPWR _1095_/A sky130_fd_sc_hd__clkbuf_4
X_2274_ _2293_/CLK _2274_/D _1242_/X VGND VGND VPWR VPWR _2274_/Q sky130_fd_sc_hd__dfrtp_1
X_1225_ _1233_/A VGND VGND VPWR VPWR _1225_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_52_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1156_ _1160_/A VGND VGND VPWR VPWR _1156_/X sky130_fd_sc_hd__clkbuf_2
X_1087_ _1084_/Y _1073_/X _1085_/X _1086_/Y _1080_/X VGND VGND VPWR VPWR _1088_/A
+ sky130_fd_sc_hd__o32a_1
X_1989_ _1989_/A VGND VGND VPWR VPWR _1989_/X sky130_fd_sc_hd__buf_1
XFILLER_32_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1912_ _2171_/Q _2170_/Q _1912_/C VGND VGND VPWR VPWR _1912_/X sky130_fd_sc_hd__or3_4
XFILLER_8_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1843_ _2139_/Q _2138_/Q _1807_/C _1818_/A VGND VGND VPWR VPWR _1843_/X sky130_fd_sc_hd__o211a_1
XFILLER_6_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1774_ _1774_/A VGND VGND VPWR VPWR _1774_/X sky130_fd_sc_hd__clkbuf_1
X_1208_ _2274_/Q _2273_/Q _1936_/B VGND VGND VPWR VPWR _1209_/B sky130_fd_sc_hd__or3_1
XFILLER_27_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2257_ _2261_/CLK _2257_/D _1368_/X VGND VGND VPWR VPWR _2257_/Q sky130_fd_sc_hd__dfrtp_1
X_1139_ _1124_/X _1095_/A _1133_/X _2301_/Q _1129_/X VGND VGND VPWR VPWR _2301_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2188_ _2222_/CLK _2188_/D _1719_/X VGND VGND VPWR VPWR _2188_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1490_ _1490_/A VGND VGND VPWR VPWR _1490_/Y sky130_fd_sc_hd__inv_2
XFILLER_3_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2042_ _2042_/A _2042_/B VGND VGND VPWR VPWR _2160_/D sky130_fd_sc_hd__or2_1
X_2111_ _2110_/X _2197_/Q _2185_/Q VGND VGND VPWR VPWR _2111_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1826_ _1497_/X _1842_/A _1804_/A _1820_/C _1825_/X VGND VGND VPWR VPWR _1826_/X
+ sky130_fd_sc_hd__o32a_2
XFILLER_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1688_ _2196_/Q VGND VGND VPWR VPWR _1688_/Y sky130_fd_sc_hd__inv_2
X_1757_ _1769_/A VGND VGND VPWR VPWR _1762_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_38_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2309_ _2312_/CLK _2309_/D _1094_/X VGND VGND VPWR VPWR _2309_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_48_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1611_ _1611_/A VGND VGND VPWR VPWR _1611_/X sky130_fd_sc_hd__clkbuf_1
X_1473_ _1469_/Y _1460_/X _1472_/Y _1463_/X VGND VGND VPWR VPWR _2233_/D sky130_fd_sc_hd__o22ai_1
XFILLER_5_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1542_ _1744_/A VGND VGND VPWR VPWR _1678_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_27_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2025_ _2155_/Q VGND VGND VPWR VPWR _2025_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1809_ _2228_/Q _1809_/B VGND VGND VPWR VPWR _1825_/C sky130_fd_sc_hd__or2_1
XFILLER_39_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1456_ _1454_/Y _1455_/X _1879_/B VGND VGND VPWR VPWR _2237_/D sky130_fd_sc_hd__o21a_1
X_1387_ _1332_/A _1359_/X _2255_/Q _1363_/X VGND VGND VPWR VPWR _2255_/D sky130_fd_sc_hd__a2bb2o_1
X_1525_ _2202_/Q _2182_/Q _1554_/A VGND VGND VPWR VPWR _1528_/A sky130_fd_sc_hd__a21oi_4
X_2008_ _2219_/Q VGND VGND VPWR VPWR _2008_/Y sky130_fd_sc_hd__inv_2
XFILLER_23_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1241_ _2072_/X _1230_/X _2275_/Q _1231_/X VGND VGND VPWR VPWR _2275_/D sky130_fd_sc_hd__a22o_1
X_2290_ _2293_/CLK _2290_/D _1174_/X VGND VGND VPWR VPWR _2290_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_37_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1310_ _1355_/A _1310_/B _1355_/C _2257_/Q VGND VGND VPWR VPWR _1379_/A sky130_fd_sc_hd__or4b_4
X_1172_ _1179_/A VGND VGND VPWR VPWR _1172_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_2_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1439_ _1449_/A VGND VGND VPWR VPWR _1439_/X sky130_fd_sc_hd__clkbuf_1
X_1508_ _1508_/A VGND VGND VPWR VPWR _2225_/D sky130_fd_sc_hd__inv_2
XFILLER_15_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1790_ _1792_/A VGND VGND VPWR VPWR _1790_/X sky130_fd_sc_hd__clkbuf_1
Xinput13 wb_dat_i[5] VGND VGND VPWR VPWR _1090_/A sky130_fd_sc_hd__buf_2
XFILLER_14_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2273_ _2293_/CLK _2273_/D _1246_/X VGND VGND VPWR VPWR _2273_/Q sky130_fd_sc_hd__dfrtp_1
X_1224_ _2078_/X _1216_/X _2282_/Q _1218_/X VGND VGND VPWR VPWR _2282_/D sky130_fd_sc_hd__a22o_1
XFILLER_52_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1155_ _1155_/A _1155_/B VGND VGND VPWR VPWR _1160_/A sky130_fd_sc_hd__nand2_2
XFILLER_37_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1086_ _2311_/Q VGND VGND VPWR VPWR _1086_/Y sky130_fd_sc_hd__inv_2
X_1988_ _1988_/A VGND VGND VPWR VPWR _1988_/X sky130_fd_sc_hd__buf_1
XFILLER_20_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1911_ _2171_/Q VGND VGND VPWR VPWR _1911_/Y sky130_fd_sc_hd__inv_2
X_1842_ _1842_/A _1842_/B _1842_/C _1842_/D VGND VGND VPWR VPWR _1842_/X sky130_fd_sc_hd__and4_1
X_1773_ _1774_/A VGND VGND VPWR VPWR _1773_/X sky130_fd_sc_hd__clkbuf_1
X_1207_ _2272_/Q _1207_/B VGND VGND VPWR VPWR _1936_/B sky130_fd_sc_hd__or2_1
XFILLER_27_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2256_ _2262_/CLK _2256_/D _1370_/X VGND VGND VPWR VPWR _2256_/Q sky130_fd_sc_hd__dfrtp_4
X_2187_ _2262_/CLK _2187_/D _1721_/X VGND VGND VPWR VPWR _2187_/Q sky130_fd_sc_hd__dfrtp_1
X_1138_ _1145_/A VGND VGND VPWR VPWR _1138_/X sky130_fd_sc_hd__clkbuf_1
X_1069_ _1524_/A VGND VGND VPWR VPWR _1279_/A sky130_fd_sc_hd__buf_1
Xclkbuf_leaf_12_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2293_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_48_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2041_ _2159_/Q _2042_/B VGND VGND VPWR VPWR _2161_/D sky130_fd_sc_hd__or2_1
X_2110_ _2236_/Q _2222_/Q _2186_/Q VGND VGND VPWR VPWR _2110_/X sky130_fd_sc_hd__mux2_1
X_1756_ _1756_/A VGND VGND VPWR VPWR _1756_/X sky130_fd_sc_hd__clkbuf_1
X_1825_ _2226_/Q _2225_/Q _1825_/C VGND VGND VPWR VPWR _1825_/X sky130_fd_sc_hd__or3_1
XFILLER_38_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2308_ _2312_/CLK _2308_/D _1099_/X VGND VGND VPWR VPWR _2308_/Q sky130_fd_sc_hd__dfrtp_1
X_1687_ _1700_/A VGND VGND VPWR VPWR _1687_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_54_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2239_ _2267_/CLK _2239_/D _1439_/X VGND VGND VPWR VPWR _2239_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_0_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1610_ _1579_/B _2204_/Q _1610_/S VGND VGND VPWR VPWR _2204_/D sky130_fd_sc_hd__mux2_1
X_1472_ _2232_/Q VGND VGND VPWR VPWR _1472_/Y sky130_fd_sc_hd__inv_2
X_1541_ _1886_/B _1527_/A _2101_/X _2218_/Q _1528_/A VGND VGND VPWR VPWR _2218_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2024_ _1497_/X _1978_/A _1688_/Y _1980_/A VGND VGND VPWR VPWR _2024_/X sky130_fd_sc_hd__o22a_1
XFILLER_10_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1739_ _1743_/A VGND VGND VPWR VPWR _1739_/X sky130_fd_sc_hd__clkbuf_1
X_1808_ _1851_/B _1808_/B _2140_/Q VGND VGND VPWR VPWR _1814_/B sky130_fd_sc_hd__and3_1
XFILLER_49_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1524_ _1524_/A _2185_/Q _2186_/Q VGND VGND VPWR VPWR _1554_/A sky130_fd_sc_hd__or3_4
X_1455_ _1441_/A _1829_/A _1437_/C _2237_/Q VGND VGND VPWR VPWR _1455_/X sky130_fd_sc_hd__o31a_1
X_1386_ _1390_/A VGND VGND VPWR VPWR _1386_/X sky130_fd_sc_hd__clkbuf_1
X_2007_ _2212_/Q VGND VGND VPWR VPWR _2007_/Y sky130_fd_sc_hd__inv_2
XFILLER_35_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1240_ _1246_/A VGND VGND VPWR VPWR _1240_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_49_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1171_ _1159_/X _1101_/B _1161_/X _2292_/Q _1156_/X VGND VGND VPWR VPWR _2292_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_49_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1507_ _1095_/Y _1501_/X _1490_/Y _1506_/Y _1490_/A VGND VGND VPWR VPWR _1508_/A
+ sky130_fd_sc_hd__o32a_1
X_1438_ _2240_/Q _1437_/X _1462_/A VGND VGND VPWR VPWR _2240_/D sky130_fd_sc_hd__a21o_1
X_1369_ _1379_/B _1359_/X _2257_/Q _1363_/X VGND VGND VPWR VPWR _2257_/D sky130_fd_sc_hd__a2bb2o_1
XFILLER_11_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput14 wb_dat_i[6] VGND VGND VPWR VPWR _1084_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_52_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1223_ _1233_/A VGND VGND VPWR VPWR _1223_/X sky130_fd_sc_hd__clkbuf_1
X_2272_ _2307_/CLK _2272_/D _1249_/X VGND VGND VPWR VPWR _2272_/Q sky130_fd_sc_hd__dfrtp_1
X_1154_ _1154_/A _2060_/S VGND VGND VPWR VPWR _1155_/B sky130_fd_sc_hd__nand2_1
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1085_ _1085_/A VGND VGND VPWR VPWR _1085_/X sky130_fd_sc_hd__buf_1
X_1987_ _2297_/Q VGND VGND VPWR VPWR _1987_/Y sky130_fd_sc_hd__inv_2
XFILLER_28_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1910_ _2300_/Q VGND VGND VPWR VPWR _1910_/Y sky130_fd_sc_hd__inv_2
X_1841_ _2140_/Q VGND VGND VPWR VPWR _1842_/C sky130_fd_sc_hd__inv_2
XFILLER_6_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1772_ _1774_/A VGND VGND VPWR VPWR _1772_/X sky130_fd_sc_hd__clkbuf_1
X_1206_ _2271_/Q _1206_/B VGND VGND VPWR VPWR _1207_/B sky130_fd_sc_hd__or2_1
X_1137_ _1124_/X _1090_/A _1133_/X _2302_/Q _1129_/X VGND VGND VPWR VPWR _2302_/D
+ sky130_fd_sc_hd__o32a_1
X_2186_ _2262_/CLK _2186_/D _1722_/X VGND VGND VPWR VPWR _2186_/Q sky130_fd_sc_hd__dfrtp_2
X_2255_ _2261_/CLK _2255_/D _1386_/X VGND VGND VPWR VPWR _2255_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_43_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1068_ _1068_/A VGND VGND VPWR VPWR _1068_/Y sky130_fd_sc_hd__inv_2
XFILLER_0_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2040_ _2201_/Q _2040_/B VGND VGND VPWR VPWR _2151_/D sky130_fd_sc_hd__nand2_1
XFILLER_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1824_ _2138_/Q VGND VGND VPWR VPWR _1842_/B sky130_fd_sc_hd__inv_2
X_1755_ _1756_/A VGND VGND VPWR VPWR _1755_/X sky130_fd_sc_hd__clkbuf_1
X_1686_ _1686_/A VGND VGND VPWR VPWR _2197_/D sky130_fd_sc_hd__inv_2
X_2307_ _2307_/CLK _2307_/D _1106_/X VGND VGND VPWR VPWR _2307_/Q sky130_fd_sc_hd__dfrtp_1
X_2238_ _2267_/CLK _2238_/D _1449_/X VGND VGND VPWR VPWR _2238_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2169_ _2172_/CLK _2169_/D _1742_/X VGND VGND VPWR VPWR _2169_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_13_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1540_ _1540_/A VGND VGND VPWR VPWR _1886_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1471_ _1471_/A VGND VGND VPWR VPWR _1471_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_5_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2023_ _1091_/Y _1976_/A _2018_/X _2021_/X _2022_/X VGND VGND VPWR VPWR _2023_/Y
+ sky130_fd_sc_hd__o2111ai_1
X_1807_ _1807_/A _2140_/Q _1807_/C VGND VGND VPWR VPWR _1814_/A sky130_fd_sc_hd__and3_1
X_1738_ _1738_/A VGND VGND VPWR VPWR _1743_/A sky130_fd_sc_hd__clkbuf_2
X_1669_ _1974_/A _1658_/A _1658_/Y _1668_/X VGND VGND VPWR VPWR _2199_/D sky130_fd_sc_hd__o22ai_1
XFILLER_26_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1523_ _1885_/B VGND VGND VPWR VPWR _1523_/X sky130_fd_sc_hd__clkbuf_2
X_1454_ _1454_/A VGND VGND VPWR VPWR _1454_/Y sky130_fd_sc_hd__inv_2
X_1385_ _1385_/A VGND VGND VPWR VPWR _2256_/D sky130_fd_sc_hd__inv_2
XFILLER_51_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2006_ _2005_/Y _1978_/X _1701_/Y _1980_/X VGND VGND VPWR VPWR _2006_/X sky130_fd_sc_hd__o22a_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_7_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2303_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_49_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1170_ _1179_/A VGND VGND VPWR VPWR _1170_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_2_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1437_ _1441_/A _1829_/A _1437_/C _1437_/D VGND VGND VPWR VPWR _1437_/X sky130_fd_sc_hd__or4_4
X_1506_ _2225_/Q VGND VGND VPWR VPWR _1506_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1299_ _1324_/A VGND VGND VPWR VPWR _1355_/C sky130_fd_sc_hd__buf_1
X_1368_ _1390_/A VGND VGND VPWR VPWR _1368_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_11_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput15 wb_dat_i[7] VGND VGND VPWR VPWR _1068_/A sky130_fd_sc_hd__clkbuf_2
X_2271_ _2307_/CLK _2271_/D _1251_/X VGND VGND VPWR VPWR _2271_/Q sky130_fd_sc_hd__dfrtp_1
X_1222_ _1248_/A VGND VGND VPWR VPWR _1233_/A sky130_fd_sc_hd__clkbuf_2
X_1084_ _1084_/A VGND VGND VPWR VPWR _1084_/Y sky130_fd_sc_hd__inv_2
XFILLER_37_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1153_ _1153_/A VGND VGND VPWR VPWR _2060_/S sky130_fd_sc_hd__clkbuf_4
X_1986_ _1982_/Y _1983_/X _1984_/Y _1985_/X VGND VGND VPWR VPWR _1986_/X sky130_fd_sc_hd__o22a_1
XFILLER_20_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1840_ _1840_/A _1840_/B VGND VGND VPWR VPWR _2145_/D sky130_fd_sc_hd__nor2_1
X_1771_ _1774_/A VGND VGND VPWR VPWR _1771_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_8_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2254_ _2254_/CLK _2254_/D _1388_/X VGND VGND VPWR VPWR _2254_/Q sky130_fd_sc_hd__dfrtp_1
X_1136_ _1145_/A VGND VGND VPWR VPWR _1136_/X sky130_fd_sc_hd__clkbuf_1
X_1205_ _2270_/Q _2269_/Q VGND VGND VPWR VPWR _1206_/B sky130_fd_sc_hd__or2_1
X_1067_ _2048_/A VGND VGND VPWR VPWR _1099_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_25_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2185_ _2262_/CLK _2185_/D _1723_/X VGND VGND VPWR VPWR _2185_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_33_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1969_ _1971_/A _1969_/B VGND VGND VPWR VPWR _2186_/D sky130_fd_sc_hd__nor2_1
XPHY_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_21_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2137_/CLK sky130_fd_sc_hd__clkbuf_16
XPHY_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1823_ _1810_/X _2142_/Q _1621_/A _1621_/A _1675_/Y VGND VGND VPWR VPWR _2142_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_15_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1754_ _1756_/A VGND VGND VPWR VPWR _1754_/X sky130_fd_sc_hd__clkbuf_1
X_1685_ _1068_/Y _1501_/X _1681_/X _1682_/Y _1684_/X VGND VGND VPWR VPWR _1686_/A
+ sky130_fd_sc_hd__o32a_1
X_2306_ _2312_/CLK _2306_/D _1111_/X VGND VGND VPWR VPWR _2306_/Q sky130_fd_sc_hd__dfrtp_1
X_2237_ _2241_/CLK _2237_/D _1453_/X VGND VGND VPWR VPWR _2237_/Q sky130_fd_sc_hd__dfrtp_1
X_2168_ _2282_/CLK _2168_/D _1743_/X VGND VGND VPWR VPWR _2168_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_54_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1119_ _2305_/Q VGND VGND VPWR VPWR _1119_/Y sky130_fd_sc_hd__inv_2
X_2099_ _2098_/X _2191_/Q _2185_/Q VGND VGND VPWR VPWR _2099_/X sky130_fd_sc_hd__mux2_1
XFILLER_21_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1470_ _1466_/Y _1460_/X _1469_/Y _1463_/X VGND VGND VPWR VPWR _2234_/D sky130_fd_sc_hd__o22ai_1
XFILLER_8_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2022_ _1918_/Y _1988_/X _1634_/Y _1989_/X VGND VGND VPWR VPWR _2022_/X sky130_fd_sc_hd__o22a_1
XFILLER_35_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1806_ _1961_/B _1800_/X _1808_/B _1805_/Y VGND VGND VPWR VPWR _2139_/D sky130_fd_sc_hd__a31o_1
X_1737_ _1737_/A VGND VGND VPWR VPWR _1737_/X sky130_fd_sc_hd__clkbuf_1
X_1599_ _1611_/A VGND VGND VPWR VPWR _1599_/X sky130_fd_sc_hd__clkbuf_1
X_1668_ _1653_/X _1664_/X _1666_/X _1667_/X _1860_/A VGND VGND VPWR VPWR _1668_/X
+ sky130_fd_sc_hd__a41o_1
XFILLER_26_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1453_ _1471_/A VGND VGND VPWR VPWR _1453_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_4_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1522_ _1522_/A VGND VGND VPWR VPWR _1522_/X sky130_fd_sc_hd__clkbuf_1
X_2005_ _2313_/Q VGND VGND VPWR VPWR _2005_/Y sky130_fd_sc_hd__inv_2
X_1384_ _1371_/Y _1358_/A _1383_/Y _1312_/B _1361_/A VGND VGND VPWR VPWR _1385_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_50_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1436_ _2160_/Q VGND VGND VPWR VPWR _1829_/A sky130_fd_sc_hd__clkbuf_2
X_1367_ _1409_/A VGND VGND VPWR VPWR _1390_/A sky130_fd_sc_hd__clkbuf_2
X_1505_ _1522_/A VGND VGND VPWR VPWR _1505_/X sky130_fd_sc_hd__clkbuf_1
X_1298_ _2252_/Q _2251_/Q _2254_/Q _2253_/Q VGND VGND VPWR VPWR _1324_/A sky130_fd_sc_hd__or4_4
XFILLER_46_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput16 wb_rst_i VGND VGND VPWR VPWR _1524_/A sky130_fd_sc_hd__buf_2
XFILLER_6_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1221_ _2064_/X _1216_/X _2283_/Q _1218_/X VGND VGND VPWR VPWR _2283_/D sky130_fd_sc_hd__a22o_1
X_2270_ _2307_/CLK _2270_/D _1253_/X VGND VGND VPWR VPWR _2270_/Q sky130_fd_sc_hd__dfrtp_1
X_1152_ _1977_/A _1979_/B _1979_/C VGND VGND VPWR VPWR _1153_/A sky130_fd_sc_hd__and3_1
XFILLER_37_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1083_ _1099_/A VGND VGND VPWR VPWR _1083_/X sky130_fd_sc_hd__clkbuf_1
X_1985_ _1985_/A VGND VGND VPWR VPWR _1985_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_9_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1419_ _2131_/Q VGND VGND VPWR VPWR _1419_/Y sky130_fd_sc_hd__inv_2
XPHY_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1770_ _1774_/A VGND VGND VPWR VPWR _1770_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_8_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1204_ _2280_/Q _2279_/Q VGND VGND VPWR VPWR _1211_/C sky130_fd_sc_hd__or2_1
X_2253_ _2254_/CLK _2253_/D _1390_/X VGND VGND VPWR VPWR _2253_/Q sky130_fd_sc_hd__dfrtp_1
X_2184_ _2262_/CLK _2184_/D _1724_/X VGND VGND VPWR VPWR _2184_/Q sky130_fd_sc_hd__dfrtp_2
X_1135_ _2048_/A VGND VGND VPWR VPWR _1145_/A sky130_fd_sc_hd__clkbuf_2
Xclkbuf_0_wb_clk_i wb_clk_i VGND VGND VPWR VPWR clkbuf_0_wb_clk_i/X sky130_fd_sc_hd__clkbuf_16
X_1066_ _1273_/A VGND VGND VPWR VPWR _2048_/A sky130_fd_sc_hd__clkbuf_2
X_1899_ _1901_/A _1909_/B _2092_/X VGND VGND VPWR VPWR _2166_/D sky130_fd_sc_hd__and3_1
X_1968_ _1960_/C _1851_/A _1810_/X _1960_/D _1967_/Y VGND VGND VPWR VPWR _1969_/B
+ sky130_fd_sc_hd__o221a_1
XFILLER_56_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1753_ _1756_/A VGND VGND VPWR VPWR _1753_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_30_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1822_ _1962_/B _1960_/D _1971_/A _1856_/A VGND VGND VPWR VPWR _2141_/D sky130_fd_sc_hd__o31ai_1
X_1684_ _1684_/A VGND VGND VPWR VPWR _1684_/X sky130_fd_sc_hd__clkbuf_2
X_2167_ _2282_/CLK _2167_/D _1746_/X VGND VGND VPWR VPWR _2167_/Q sky130_fd_sc_hd__dfrtp_1
X_2305_ _2312_/CLK _2305_/D _1117_/X VGND VGND VPWR VPWR _2305_/Q sky130_fd_sc_hd__dfrtp_1
X_2236_ _2241_/CLK _2236_/D _1457_/X VGND VGND VPWR VPWR _2236_/Q sky130_fd_sc_hd__dfrtp_1
X_1118_ _1540_/A input8/X VGND VGND VPWR VPWR _1118_/Y sky130_fd_sc_hd__nand2_2
X_2098_ _2230_/Q _2216_/Q _2186_/Q VGND VGND VPWR VPWR _2098_/X sky130_fd_sc_hd__mux2_1
XFILLER_21_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2021_ _2019_/Y _1983_/A _2020_/Y _1681_/X VGND VGND VPWR VPWR _2021_/X sky130_fd_sc_hd__o22a_1
XFILLER_50_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1805_ _1805_/A VGND VGND VPWR VPWR _1805_/Y sky130_fd_sc_hd__inv_2
X_1736_ _1737_/A VGND VGND VPWR VPWR _1736_/X sky130_fd_sc_hd__clkbuf_1
X_1598_ _1280_/A _1107_/A _1587_/X _2207_/Q _1588_/X VGND VGND VPWR VPWR _2207_/D
+ sky130_fd_sc_hd__o32a_1
X_1667_ _1851_/A _1667_/B _1667_/C VGND VGND VPWR VPWR _1667_/X sky130_fd_sc_hd__or3_1
XFILLER_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2219_ _2222_/CLK _2219_/D _1537_/X VGND VGND VPWR VPWR _2219_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_14_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1452_ _1530_/A VGND VGND VPWR VPWR _1471_/A sky130_fd_sc_hd__clkbuf_2
X_1383_ _1383_/A _1383_/B VGND VGND VPWR VPWR _1383_/Y sky130_fd_sc_hd__nand2_2
X_1521_ _2224_/Q _1519_/X _1519_/X _1520_/X VGND VGND VPWR VPWR _2224_/D sky130_fd_sc_hd__o2bb2ai_1
X_2004_ _1108_/Y _1976_/X _1998_/X _2001_/X _2003_/X VGND VGND VPWR VPWR _2004_/Y
+ sky130_fd_sc_hd__o2111ai_4
XFILLER_50_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1719_ _1719_/A VGND VGND VPWR VPWR _1719_/X sky130_fd_sc_hd__clkbuf_1
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1504_ _1504_/A VGND VGND VPWR VPWR _2226_/D sky130_fd_sc_hd__inv_2
X_1435_ _1449_/A VGND VGND VPWR VPWR _1435_/X sky130_fd_sc_hd__clkbuf_1
X_1366_ _1379_/A _1359_/X _2258_/Q _1363_/X VGND VGND VPWR VPWR _2258_/D sky130_fd_sc_hd__a2bb2o_1
X_1297_ _1375_/A VGND VGND VPWR VPWR _1356_/A sky130_fd_sc_hd__buf_1
XFILLER_11_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_15_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2311_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_2_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput17 wb_stb_i VGND VGND VPWR VPWR _2034_/B sky130_fd_sc_hd__clkbuf_1
X_1220_ _1220_/A VGND VGND VPWR VPWR _1220_/X sky130_fd_sc_hd__clkbuf_1
X_1151_ _1151_/A VGND VGND VPWR VPWR _1154_/A sky130_fd_sc_hd__inv_2
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1082_ _1082_/A VGND VGND VPWR VPWR _2312_/D sky130_fd_sc_hd__inv_2
XFILLER_37_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1984_ _2216_/Q VGND VGND VPWR VPWR _1984_/Y sky130_fd_sc_hd__inv_2
X_1418_ _1418_/A VGND VGND VPWR VPWR _1418_/X sky130_fd_sc_hd__clkbuf_1
X_1349_ _1349_/A VGND VGND VPWR VPWR _1380_/B sky130_fd_sc_hd__inv_2
XPHY_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1203_ _2284_/Q _2283_/Q VGND VGND VPWR VPWR _1212_/C sky130_fd_sc_hd__or2_1
X_1134_ _1124_/X _1084_/A _1133_/X _2303_/Q _1129_/X VGND VGND VPWR VPWR _2303_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2252_ _2262_/CLK _2252_/D _1395_/X VGND VGND VPWR VPWR _2252_/Q sky130_fd_sc_hd__dfrtp_2
X_2183_ _2262_/CLK _2183_/D _1725_/X VGND VGND VPWR VPWR _2183_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_33_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1065_ input1/X VGND VGND VPWR VPWR _1273_/A sky130_fd_sc_hd__inv_2
XFILLER_18_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1898_ _2166_/Q _1897_/B _1897_/X VGND VGND VPWR VPWR _1898_/X sky130_fd_sc_hd__a21bo_1
X_1967_ _2140_/Q _2136_/Q _2084_/X _1851_/B VGND VGND VPWR VPWR _1967_/Y sky130_fd_sc_hd__o211ai_1
XFILLER_0_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1752_ _1756_/A VGND VGND VPWR VPWR _1752_/X sky130_fd_sc_hd__clkbuf_1
X_1683_ _1181_/B _1985_/A _1155_/A VGND VGND VPWR VPWR _1684_/A sky130_fd_sc_hd__o21ai_2
X_1821_ _1961_/B _1804_/A _1960_/D _1818_/X _1820_/X VGND VGND VPWR VPWR _1856_/A
+ sky130_fd_sc_hd__o311a_1
X_2304_ _2313_/CLK _2304_/D _1122_/X VGND VGND VPWR VPWR _2304_/Q sky130_fd_sc_hd__dfstp_1
X_2166_ _2282_/CLK _2166_/D _1747_/X VGND VGND VPWR VPWR _2166_/Q sky130_fd_sc_hd__dfrtp_1
X_1117_ _1131_/A VGND VGND VPWR VPWR _1117_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_38_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2235_ _2241_/CLK _2235_/D _1465_/X VGND VGND VPWR VPWR _2235_/Q sky130_fd_sc_hd__dfrtp_1
X_2097_ _1958_/X _2190_/Q _2185_/Q VGND VGND VPWR VPWR _2097_/X sky130_fd_sc_hd__mux2_1
XFILLER_29_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2020_ _2221_/Q VGND VGND VPWR VPWR _2020_/Y sky130_fd_sc_hd__inv_2
X_1804_ _1804_/A VGND VGND VPWR VPWR _1808_/B sky130_fd_sc_hd__inv_2
X_1735_ _1737_/A VGND VGND VPWR VPWR _1735_/X sky130_fd_sc_hd__clkbuf_1
X_1666_ _1960_/C _1666_/B _1666_/C VGND VGND VPWR VPWR _1666_/X sky130_fd_sc_hd__or3_2
X_1597_ _1611_/A VGND VGND VPWR VPWR _1597_/X sky130_fd_sc_hd__clkbuf_1
X_2218_ _2260_/CLK _2218_/D _1539_/X VGND VGND VPWR VPWR _2218_/Q sky130_fd_sc_hd__dfrtp_1
X_2149_ _2224_/CLK _2149_/D _1767_/X VGND VGND VPWR VPWR _2149_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1520_ _2148_/Q _1520_/B _1520_/C VGND VGND VPWR VPWR _1520_/X sky130_fd_sc_hd__and3_1
X_1451_ _1446_/Y _1450_/X _1879_/B VGND VGND VPWR VPWR _2238_/D sky130_fd_sc_hd__o21a_1
X_1382_ _1382_/A _1880_/C _1332_/X VGND VGND VPWR VPWR _1383_/B sky130_fd_sc_hd__nor3b_4
X_2003_ _2002_/Y _1988_/X _1625_/Y _1989_/X VGND VGND VPWR VPWR _2003_/X sky130_fd_sc_hd__o22a_1
XFILLER_35_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1718_ _1719_/A VGND VGND VPWR VPWR _1718_/X sky130_fd_sc_hd__clkbuf_1
X_1649_ _2133_/Q VGND VGND VPWR VPWR _1664_/B sky130_fd_sc_hd__inv_2
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1503_ _1090_/Y _1501_/X _1490_/Y _1820_/A _1490_/A VGND VGND VPWR VPWR _1504_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_55_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1434_ _1462_/A _1432_/Y _1879_/A VGND VGND VPWR VPWR _2241_/D sky130_fd_sc_hd__o21a_1
X_1296_ _1330_/A VGND VGND VPWR VPWR _1375_/A sky130_fd_sc_hd__clkbuf_2
X_1365_ _1365_/A VGND VGND VPWR VPWR _1365_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_46_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput18 wb_we_i VGND VGND VPWR VPWR _1057_/A sky130_fd_sc_hd__buf_1
XFILLER_52_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1150_ _1165_/A VGND VGND VPWR VPWR _1150_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_28_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1081_ _1068_/Y _1073_/X _1976_/A _1202_/A _1080_/X VGND VGND VPWR VPWR _1082_/A
+ sky130_fd_sc_hd__o32a_1
X_1983_ _1983_/A VGND VGND VPWR VPWR _1983_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_9_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1417_ _1343_/B _1391_/X _2244_/Q _1363_/A VGND VGND VPWR VPWR _2244_/D sky130_fd_sc_hd__a2bb2o_1
X_1279_ _1279_/A VGND VGND VPWR VPWR _1280_/A sky130_fd_sc_hd__buf_2
X_1348_ _1377_/A _1348_/B _2247_/Q _1348_/D VGND VGND VPWR VPWR _1349_/A sky130_fd_sc_hd__or4_4
XPHY_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2251_ _2254_/CLK _2251_/D _1399_/X VGND VGND VPWR VPWR _2251_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_6_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1133_ _1133_/A VGND VGND VPWR VPWR _1133_/X sky130_fd_sc_hd__clkbuf_2
X_1064_ _1909_/B _1101_/B _1063_/A _2313_/Q _1063_/Y VGND VGND VPWR VPWR _2313_/D
+ sky130_fd_sc_hd__a32o_1
X_1202_ _1202_/A _1524_/A VGND VGND VPWR VPWR _1927_/B sky130_fd_sc_hd__or2_2
X_2182_ _2241_/CLK _2182_/D _1727_/X VGND VGND VPWR VPWR _2182_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_33_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_0_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2224_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_18_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1966_ _2083_/X _1975_/B VGND VGND VPWR VPWR _2187_/D sky130_fd_sc_hd__nor2_1
X_1897_ _2166_/Q _1897_/B VGND VGND VPWR VPWR _1897_/X sky130_fd_sc_hd__or2_1
XFILLER_24_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1820_ _1820_/A _1825_/C _1820_/C VGND VGND VPWR VPWR _1820_/X sky130_fd_sc_hd__or3_1
X_1751_ _1769_/A VGND VGND VPWR VPWR _1756_/A sky130_fd_sc_hd__buf_1
XFILLER_30_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1682_ _2197_/Q VGND VGND VPWR VPWR _1682_/Y sky130_fd_sc_hd__inv_2
X_2303_ _2303_/CLK _2303_/D _1131_/X VGND VGND VPWR VPWR _2303_/Q sky130_fd_sc_hd__dfstp_1
X_2234_ _2234_/CLK _2234_/D _1468_/X VGND VGND VPWR VPWR _2234_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2165_ _2282_/CLK _2165_/D _1748_/X VGND VGND VPWR VPWR _2165_/Q sky130_fd_sc_hd__dfrtp_1
X_1116_ _1116_/A VGND VGND VPWR VPWR _2306_/D sky130_fd_sc_hd__inv_2
XFILLER_38_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2096_ _1334_/X _1306_/B _2259_/Q VGND VGND VPWR VPWR _2096_/X sky130_fd_sc_hd__mux2_1
X_1949_ _1948_/Y _1946_/Y _1950_/B VGND VGND VPWR VPWR _1949_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_9_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1803_ _1818_/A _1819_/A VGND VGND VPWR VPWR _1804_/A sky130_fd_sc_hd__or2_2
X_1734_ _1737_/A VGND VGND VPWR VPWR _1734_/X sky130_fd_sc_hd__clkbuf_1
X_1665_ _1665_/A VGND VGND VPWR VPWR _1960_/C sky130_fd_sc_hd__buf_1
X_1596_ _1678_/A VGND VGND VPWR VPWR _1611_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2217_ _2229_/CLK _2217_/D _1544_/X VGND VGND VPWR VPWR _2217_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2079_ _1951_/X _2301_/Q _2180_/D VGND VGND VPWR VPWR _2079_/X sky130_fd_sc_hd__mux2_1
X_2148_ _2224_/CLK _2148_/D _1768_/X VGND VGND VPWR VPWR _2148_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1450_ _2238_/Q _1454_/A VGND VGND VPWR VPWR _1450_/X sky130_fd_sc_hd__and2_1
XFILLER_4_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1381_ _1381_/A _1381_/B _1337_/X VGND VGND VPWR VPWR _1880_/C sky130_fd_sc_hd__or3b_4
XFILLER_50_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2002_ _2299_/Q VGND VGND VPWR VPWR _2002_/Y sky130_fd_sc_hd__inv_2
XFILLER_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1717_ _1717_/A VGND VGND VPWR VPWR _2190_/D sky130_fd_sc_hd__inv_2
X_1648_ _2135_/Q VGND VGND VPWR VPWR _1665_/A sky130_fd_sc_hd__inv_2
X_1579_ _1666_/B _1579_/B VGND VGND VPWR VPWR _1579_/Y sky130_fd_sc_hd__nand2_1
XFILLER_26_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1433_ _2157_/Q VGND VGND VPWR VPWR _1879_/A sky130_fd_sc_hd__inv_2
X_1502_ _2226_/Q VGND VGND VPWR VPWR _1820_/A sky130_fd_sc_hd__inv_2
X_1295_ _2259_/Q VGND VGND VPWR VPWR _1330_/A sky130_fd_sc_hd__buf_1
X_1364_ _1383_/A _1359_/X _1356_/A _1363_/X VGND VGND VPWR VPWR _2259_/D sky130_fd_sc_hd__a2bb2o_1
XFILLER_11_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_24_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2262_/CLK sky130_fd_sc_hd__clkbuf_16
X_1080_ _1080_/A VGND VGND VPWR VPWR _1080_/X sky130_fd_sc_hd__clkbuf_2
X_1982_ _2127_/Q VGND VGND VPWR VPWR _1982_/Y sky130_fd_sc_hd__inv_2
XFILLER_20_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1416_ _1418_/A VGND VGND VPWR VPWR _1416_/X sky130_fd_sc_hd__clkbuf_1
X_1347_ _1356_/A _1348_/D _2247_/Q _1348_/B VGND VGND VPWR VPWR _1381_/B sky130_fd_sc_hd__and4bb_1
XPHY_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1278_ _1286_/A VGND VGND VPWR VPWR _1278_/X sky130_fd_sc_hd__clkbuf_1
XPHY_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1201_ _2158_/Q VGND VGND VPWR VPWR _1441_/A sky130_fd_sc_hd__inv_2
X_2250_ _2250_/CLK _2250_/D _1401_/X VGND VGND VPWR VPWR _2250_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_6_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1063_ _1063_/A VGND VGND VPWR VPWR _1063_/Y sky130_fd_sc_hd__inv_2
X_1132_ _1132_/A VGND VGND VPWR VPWR _1133_/A sky130_fd_sc_hd__inv_2
X_2181_ _2241_/CLK _2181_/D _1728_/X VGND VGND VPWR VPWR _2181_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1965_ _1842_/A _1962_/Y _1961_/A _1963_/X _1964_/X VGND VGND VPWR VPWR _1965_/X
+ sky130_fd_sc_hd__o221a_1
X_1896_ _1901_/A _1896_/B _2062_/X VGND VGND VPWR VPWR _2165_/D sky130_fd_sc_hd__and3_1
XFILLER_33_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1750_ _1750_/A VGND VGND VPWR VPWR _1750_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_30_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1681_ _1985_/A VGND VGND VPWR VPWR _1681_/X sky130_fd_sc_hd__clkbuf_2
X_2302_ _2303_/CLK _2302_/D _1136_/X VGND VGND VPWR VPWR _2302_/Q sky130_fd_sc_hd__dfstp_1
X_2164_ _2234_/CLK _2164_/D _1749_/X VGND VGND VPWR VPWR _2164_/Q sky130_fd_sc_hd__dfrtp_1
X_2233_ _2234_/CLK _2233_/D _1471_/X VGND VGND VPWR VPWR _2233_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2095_ _1905_/Y _1904_/Y _2095_/S VGND VGND VPWR VPWR _2095_/X sky130_fd_sc_hd__mux2_1
X_1115_ _1112_/Y _1113_/X _1085_/X _1114_/Y _1080_/A VGND VGND VPWR VPWR _1116_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_0_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1948_ _2280_/Q VGND VGND VPWR VPWR _1948_/Y sky130_fd_sc_hd__inv_2
X_1879_ _1879_/A _1879_/B _2241_/Q _1879_/D VGND VGND VPWR VPWR _2152_/D sky130_fd_sc_hd__and4_1
XFILLER_0_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1802_ _1807_/A VGND VGND VPWR VPWR _1818_/A sky130_fd_sc_hd__buf_1
X_1733_ _1737_/A VGND VGND VPWR VPWR _1733_/X sky130_fd_sc_hd__clkbuf_1
X_1595_ _1280_/A _1101_/B _1587_/X _2208_/Q _1588_/X VGND VGND VPWR VPWR _2208_/D
+ sky130_fd_sc_hd__o32a_1
X_1664_ _1664_/A _1664_/B VGND VGND VPWR VPWR _1664_/X sky130_fd_sc_hd__or2_1
XFILLER_38_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2147_ _2224_/CLK _2147_/D _1770_/X VGND VGND VPWR VPWR _2147_/Q sky130_fd_sc_hd__dfrtp_1
X_2216_ _2229_/CLK _2216_/D _1546_/X VGND VGND VPWR VPWR _2216_/Q sky130_fd_sc_hd__dfrtp_1
X_2078_ _1953_/X _2302_/Q _2180_/D VGND VGND VPWR VPWR _2078_/X sky130_fd_sc_hd__mux2_1
XFILLER_5_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1380_ _1380_/A _1380_/B _1380_/C _1338_/X VGND VGND VPWR VPWR _1382_/A sky130_fd_sc_hd__or4b_4
X_2001_ _1999_/Y _1983_/X _2000_/Y _1985_/X VGND VGND VPWR VPWR _2001_/X sky130_fd_sc_hd__o22a_1
XFILLER_50_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1716_ _1181_/B _1696_/X _1118_/Y _1715_/Y _1684_/A VGND VGND VPWR VPWR _1717_/A
+ sky130_fd_sc_hd__o32a_1
X_1647_ _2136_/Q VGND VGND VPWR VPWR _1667_/C sky130_fd_sc_hd__inv_2
X_1578_ _2150_/Q VGND VGND VPWR VPWR _1666_/B sky130_fd_sc_hd__inv_2
XFILLER_25_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1501_ _1501_/A VGND VGND VPWR VPWR _1501_/X sky130_fd_sc_hd__dlymetal6s2s_1
X_1432_ _1437_/C _1879_/D VGND VGND VPWR VPWR _1432_/Y sky130_fd_sc_hd__nor2_1
X_1363_ _1363_/A VGND VGND VPWR VPWR _1363_/X sky130_fd_sc_hd__buf_1
XFILLER_55_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1294_ _1569_/C VGND VGND VPWR VPWR _1357_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_23_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1981_ _1191_/Y _1978_/X _1715_/Y _1980_/X VGND VGND VPWR VPWR _1981_/X sky130_fd_sc_hd__o22a_1
XFILLER_13_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1415_ _1338_/X _1391_/X _2245_/Q _1363_/A VGND VGND VPWR VPWR _2245_/D sky130_fd_sc_hd__a2bb2o_1
X_1346_ _2248_/Q VGND VGND VPWR VPWR _1348_/B sky130_fd_sc_hd__inv_2
XPHY_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1277_ _2266_/Q _2095_/S _2267_/Q _1270_/X _2042_/B VGND VGND VPWR VPWR _2267_/D
+ sky130_fd_sc_hd__a221o_1
XFILLER_36_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1200_ _2181_/Q VGND VGND VPWR VPWR _1215_/A sky130_fd_sc_hd__inv_2
X_2180_ _2241_/CLK _2180_/D _1729_/X VGND VGND VPWR VPWR _2180_/Q sky130_fd_sc_hd__dfstp_1
X_1131_ _1131_/A VGND VGND VPWR VPWR _1131_/X sky130_fd_sc_hd__clkbuf_1
X_1062_ _1070_/A _1061_/X _1078_/A VGND VGND VPWR VPWR _1063_/A sky130_fd_sc_hd__o21ai_1
X_1895_ _2165_/Q _1261_/B _1897_/B VGND VGND VPWR VPWR _1895_/X sky130_fd_sc_hd__a21bo_1
XFILLER_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1964_ _2141_/Q _2086_/X _1960_/C _2082_/X VGND VGND VPWR VPWR _1964_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_56_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1329_ _2252_/Q VGND VGND VPWR VPWR _1330_/B sky130_fd_sc_hd__inv_2
XFILLER_17_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2301_ _2303_/CLK _2301_/D _1138_/X VGND VGND VPWR VPWR _2301_/Q sky130_fd_sc_hd__dfstp_1
X_1680_ _1977_/A _1979_/B input6/X VGND VGND VPWR VPWR _1985_/A sky130_fd_sc_hd__or3_4
X_1114_ _2306_/Q VGND VGND VPWR VPWR _1114_/Y sky130_fd_sc_hd__inv_2
X_2163_ _2282_/CLK _2163_/D _1750_/X VGND VGND VPWR VPWR _2163_/Q sky130_fd_sc_hd__dfrtp_1
X_2232_ _2260_/CLK _2232_/D _1475_/X VGND VGND VPWR VPWR _2232_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2094_ _1926_/Y _1925_/Y _2095_/S VGND VGND VPWR VPWR _2094_/X sky130_fd_sc_hd__mux2_1
X_1947_ _2279_/Q _1946_/B _1946_/Y VGND VGND VPWR VPWR _1947_/X sky130_fd_sc_hd__a21o_1
X_1878_ _2147_/Q _2145_/Q _1441_/A _1829_/A _2040_/B VGND VGND VPWR VPWR _2150_/D
+ sky130_fd_sc_hd__o2111a_1
XFILLER_0_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1732_ _1738_/A VGND VGND VPWR VPWR _1737_/A sky130_fd_sc_hd__buf_1
X_1801_ _2153_/Q VGND VGND VPWR VPWR _1807_/A sky130_fd_sc_hd__inv_2
X_1663_ _2199_/Q VGND VGND VPWR VPWR _1974_/A sky130_fd_sc_hd__inv_2
XFILLER_11_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1594_ _1594_/A VGND VGND VPWR VPWR _1594_/X sky130_fd_sc_hd__clkbuf_1
X_2077_ _1949_/Y _2300_/Q _2180_/D VGND VGND VPWR VPWR _2077_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2146_ _2224_/CLK _2146_/D _1771_/X VGND VGND VPWR VPWR _2146_/Q sky130_fd_sc_hd__dfrtp_1
X_2215_ _2229_/CLK _2215_/D _1548_/X VGND VGND VPWR VPWR _2215_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_14_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_18_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2286_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_55_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2000_ _2218_/Q VGND VGND VPWR VPWR _2000_/Y sky130_fd_sc_hd__inv_2
XFILLER_35_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1715_ _2190_/Q VGND VGND VPWR VPWR _1715_/Y sky130_fd_sc_hd__inv_2
X_1646_ _1666_/C VGND VGND VPWR VPWR _1851_/B sky130_fd_sc_hd__clkbuf_2
X_1577_ _1187_/A _1575_/Y _1571_/A _2134_/Q _1807_/C VGND VGND VPWR VPWR _1580_/B
+ sky130_fd_sc_hd__o221a_1
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2129_ _2142_/CLK _2129_/D _1791_/X VGND VGND VPWR VPWR _2129_/Q sky130_fd_sc_hd__dfrtp_1
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1500_ _1522_/A VGND VGND VPWR VPWR _1500_/X sky130_fd_sc_hd__clkbuf_1
X_1431_ _1442_/C VGND VGND VPWR VPWR _1879_/D sky130_fd_sc_hd__inv_2
X_1362_ _1392_/A VGND VGND VPWR VPWR _1363_/A sky130_fd_sc_hd__clkbuf_2
X_1293_ _2154_/Q _1524_/A VGND VGND VPWR VPWR _1569_/C sky130_fd_sc_hd__or2_1
XFILLER_48_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1629_ _2230_/Q _1602_/Y _1461_/Y _2210_/Q _1628_/X VGND VGND VPWR VPWR _1638_/B
+ sky130_fd_sc_hd__o221a_1
XFILLER_11_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1980_ _1980_/A VGND VGND VPWR VPWR _1980_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1276_ _1286_/A VGND VGND VPWR VPWR _1276_/X sky130_fd_sc_hd__clkbuf_1
X_1414_ _1418_/A VGND VGND VPWR VPWR _1414_/X sky130_fd_sc_hd__clkbuf_1
X_1345_ _2250_/Q _2249_/Q _1372_/C _1374_/D VGND VGND VPWR VPWR _1348_/D sky130_fd_sc_hd__or4_4
XPHY_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1130_ _1124_/X _1068_/A _1128_/B _2304_/Q _1129_/X VGND VGND VPWR VPWR _2304_/D
+ sky130_fd_sc_hd__o32a_1
X_1061_ _1202_/A _1983_/A VGND VGND VPWR VPWR _1061_/X sky130_fd_sc_hd__or2_2
X_1894_ _1901_/A _1896_/B _2061_/X VGND VGND VPWR VPWR _2164_/D sky130_fd_sc_hd__and3_1
X_1963_ _1571_/A _1851_/A _1639_/X VGND VGND VPWR VPWR _1963_/X sky130_fd_sc_hd__o21a_1
XFILLER_56_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1259_ _2163_/Q _2162_/Q VGND VGND VPWR VPWR _1260_/B sky130_fd_sc_hd__or2_1
X_1328_ _2252_/Q _1330_/C _1328_/C _1337_/D VGND VGND VPWR VPWR _1332_/C sky130_fd_sc_hd__or4_4
XFILLER_33_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2300_ _2303_/CLK _2300_/D _1140_/X VGND VGND VPWR VPWR _2300_/Q sky130_fd_sc_hd__dfstp_1
X_2231_ _2260_/CLK _2231_/D _1478_/X VGND VGND VPWR VPWR _2231_/Q sky130_fd_sc_hd__dfrtp_1
X_2093_ _1920_/Y _1918_/Y _2095_/S VGND VGND VPWR VPWR _2093_/X sky130_fd_sc_hd__mux2_1
X_2162_ _2268_/CLK _2162_/D _1752_/X VGND VGND VPWR VPWR _2162_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_38_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1113_ _1113_/A VGND VGND VPWR VPWR _1113_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_0_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1946_ _2279_/Q _1946_/B VGND VGND VPWR VPWR _1946_/Y sky130_fd_sc_hd__nor2_1
X_1877_ _2042_/B _1877_/B VGND VGND VPWR VPWR _2124_/D sky130_fd_sc_hd__nor2_1
XFILLER_29_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1800_ _2141_/Q _2140_/Q VGND VGND VPWR VPWR _1800_/X sky130_fd_sc_hd__or2_1
X_1731_ _1731_/A VGND VGND VPWR VPWR _1731_/X sky130_fd_sc_hd__clkbuf_1
X_1662_ _1670_/A VGND VGND VPWR VPWR _1662_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_7_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1593_ _1175_/X _1095_/A _1587_/X _2209_/Q _1588_/X VGND VGND VPWR VPWR _2209_/D
+ sky130_fd_sc_hd__o32a_1
X_2214_ _2229_/CLK _2214_/D _1556_/X VGND VGND VPWR VPWR _2214_/Q sky130_fd_sc_hd__dfrtp_4
X_2076_ _1947_/X _2299_/Q _2180_/D VGND VGND VPWR VPWR _2076_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2145_ _2224_/CLK _2145_/D _1772_/X VGND VGND VPWR VPWR _2145_/Q sky130_fd_sc_hd__dfrtp_1
X_1929_ _1930_/A _2178_/Q VGND VGND VPWR VPWR _2179_/D sky130_fd_sc_hd__and2_1
XFILLER_39_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1714_ _1719_/A VGND VGND VPWR VPWR _1714_/X sky130_fd_sc_hd__clkbuf_1
X_1645_ _1666_/B VGND VGND VPWR VPWR _1851_/A sky130_fd_sc_hd__clkbuf_2
X_1576_ _1576_/A VGND VGND VPWR VPWR _1807_/C sky130_fd_sc_hd__inv_2
XFILLER_34_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2059_ _2029_/Y _2295_/Q _2060_/S VGND VGND VPWR VPWR _2118_/D sky130_fd_sc_hd__mux2_1
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2128_ _2137_/CLK _2128_/D _1792_/X VGND VGND VPWR VPWR _2128_/Q sky130_fd_sc_hd__dfrtp_1
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1430_ _2240_/Q _1437_/D VGND VGND VPWR VPWR _1442_/C sky130_fd_sc_hd__or2_1
X_1361_ _1361_/A VGND VGND VPWR VPWR _1392_/A sky130_fd_sc_hd__inv_2
X_1292_ _1365_/A VGND VGND VPWR VPWR _1292_/X sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_3_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2267_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_31_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1628_ _1479_/Y _2205_/Q _2310_/Q _2182_/D VGND VGND VPWR VPWR _1628_/X sky130_fd_sc_hd__o211a_1
X_1559_ _1557_/Y _1563_/A _2214_/Q _2213_/Q _2185_/Q VGND VGND VPWR VPWR _1559_/Y
+ sky130_fd_sc_hd__a221oi_2
XFILLER_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1413_ _1391_/A _1378_/D _2246_/Q _1363_/A VGND VGND VPWR VPWR _2246_/D sky130_fd_sc_hd__a2bb2o_1
X_1275_ _1409_/A VGND VGND VPWR VPWR _1286_/A sky130_fd_sc_hd__buf_1
XFILLER_36_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1344_ _2096_/X VGND VGND VPWR VPWR _1381_/A sky130_fd_sc_hd__inv_2
XFILLER_11_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1060_ input5/X input4/X _1979_/C VGND VGND VPWR VPWR _1983_/A sky130_fd_sc_hd__or3_4
X_1962_ _2313_/Q _1962_/B VGND VGND VPWR VPWR _1962_/Y sky130_fd_sc_hd__nor2_1
X_1893_ _2164_/Q _1260_/B _1261_/B VGND VGND VPWR VPWR _1893_/X sky130_fd_sc_hd__a21bo_1
X_1258_ _2173_/Q _2172_/Q VGND VGND VPWR VPWR _1265_/C sky130_fd_sc_hd__or2_1
XFILLER_24_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1327_ _1330_/A _1337_/A _1337_/B VGND VGND VPWR VPWR _1328_/C sky130_fd_sc_hd__or3b_2
XPHY_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1189_ _1189_/A VGND VGND VPWR VPWR _2287_/D sky130_fd_sc_hd__inv_2
XFILLER_24_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2230_ _2260_/CLK _2230_/D _1481_/X VGND VGND VPWR VPWR _2230_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_2_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2092_ _1898_/X _2295_/Q _2095_/S VGND VGND VPWR VPWR _2092_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1112_ input9/X VGND VGND VPWR VPWR _1112_/Y sky130_fd_sc_hd__inv_2
X_2161_ _2241_/CLK _2161_/D _1753_/X VGND VGND VPWR VPWR _2161_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_0_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1945_ _2278_/Q _1944_/B _1946_/B VGND VGND VPWR VPWR _1945_/X sky130_fd_sc_hd__a21bo_1
XFILLER_21_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1876_ _1674_/A _2124_/Q _2154_/Q VGND VGND VPWR VPWR _1877_/B sky130_fd_sc_hd__a21oi_1
XFILLER_56_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1592_ _1594_/A VGND VGND VPWR VPWR _1592_/X sky130_fd_sc_hd__clkbuf_1
X_1730_ _1731_/A VGND VGND VPWR VPWR _1730_/X sky130_fd_sc_hd__clkbuf_1
X_1661_ _1661_/A VGND VGND VPWR VPWR _2200_/D sky130_fd_sc_hd__inv_2
XFILLER_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2144_ _2261_/CLK _2144_/D _1773_/X VGND VGND VPWR VPWR _2144_/Q sky130_fd_sc_hd__dfrtp_1
X_2213_ _2229_/CLK _2213_/D _1562_/X VGND VGND VPWR VPWR _2213_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_53_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2075_ _1945_/X _2298_/Q _2180_/D VGND VGND VPWR VPWR _2075_/X sky130_fd_sc_hd__mux2_1
XFILLER_26_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1928_ _1930_/A input3/X VGND VGND VPWR VPWR _2178_/D sky130_fd_sc_hd__and2_1
XFILLER_30_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1859_ _1371_/Y _1848_/Y _1813_/X _1858_/Y VGND VGND VPWR VPWR _2129_/D sky130_fd_sc_hd__o211ai_1
XFILLER_39_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_27_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2261_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_20_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1713_ _1713_/A VGND VGND VPWR VPWR _2191_/D sky130_fd_sc_hd__inv_2
X_1644_ _1818_/D VGND VGND VPWR VPWR _1860_/A sky130_fd_sc_hd__clkbuf_2
X_1575_ _2134_/Q VGND VGND VPWR VPWR _1575_/Y sky130_fd_sc_hd__inv_2
XANTENNA_0 _2124_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2127_ _2286_/CLK _2127_/D _1794_/X VGND VGND VPWR VPWR _2127_/Q sky130_fd_sc_hd__dfrtp_1
X_2058_ _2023_/Y _2294_/Q _2060_/S VGND VGND VPWR VPWR _2117_/D sky130_fd_sc_hd__mux2_1
XFILLER_26_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1360_ _2180_/Q _1569_/C VGND VGND VPWR VPWR _1361_/A sky130_fd_sc_hd__or2_2
XFILLER_0_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1291_ _2262_/Q _2180_/Q _1357_/A _2130_/Q _1931_/A VGND VGND VPWR VPWR _2262_/D
+ sky130_fd_sc_hd__o221a_1
XFILLER_31_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1627_ _2233_/Q _1624_/Y _1469_/Y _2208_/Q _1626_/X VGND VGND VPWR VPWR _1627_/X
+ sky130_fd_sc_hd__a221o_1
X_1489_ _1154_/A _1488_/Y _1063_/Y VGND VGND VPWR VPWR _1490_/A sky130_fd_sc_hd__o21ai_4
X_1558_ _2213_/Q VGND VGND VPWR VPWR _1563_/A sky130_fd_sc_hd__inv_2
XFILLER_39_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1412_ _1418_/A VGND VGND VPWR VPWR _1412_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_3_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1343_ _1343_/A _1343_/B VGND VGND VPWR VPWR _1351_/B sky130_fd_sc_hd__nand2_1
XFILLER_51_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1274_ _1744_/A VGND VGND VPWR VPWR _1409_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_51_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_wb_clk_i clkbuf_0_wb_clk_i/X VGND VGND VPWR VPWR clkbuf_leaf_9_wb_clk_i/A
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_6_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1892_ _1901_/A _1896_/B _2063_/X VGND VGND VPWR VPWR _2163_/D sky130_fd_sc_hd__and3_1
XFILLER_33_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1961_ _1961_/A _1961_/B VGND VGND VPWR VPWR _1961_/X sky130_fd_sc_hd__or2_1
XFILLER_5_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1326_ _1375_/A _2244_/Q _1326_/C _1338_/B VGND VGND VPWR VPWR _1343_/B sky130_fd_sc_hd__or4_4
X_1257_ _1257_/A VGND VGND VPWR VPWR _1257_/X sky130_fd_sc_hd__buf_1
X_1188_ _1112_/Y _1113_/X _1061_/X _1187_/X _1181_/X VGND VGND VPWR VPWR _1189_/A
+ sky130_fd_sc_hd__o32a_1
XPHY_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2160_ _2267_/CLK _2160_/D _1754_/X VGND VGND VPWR VPWR _2160_/Q sky130_fd_sc_hd__dfstp_1
X_1111_ _1131_/A VGND VGND VPWR VPWR _1111_/X sky130_fd_sc_hd__clkbuf_1
X_2091_ _2162_/Q _1887_/Y _2095_/S VGND VGND VPWR VPWR _2091_/X sky130_fd_sc_hd__mux2_1
X_1944_ _2278_/Q _1944_/B VGND VGND VPWR VPWR _1946_/B sky130_fd_sc_hd__or2_1
XFILLER_9_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1875_ _2203_/Q _1931_/A VGND VGND VPWR VPWR _2125_/D sky130_fd_sc_hd__and2_1
XFILLER_56_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2289_ _2289_/CLK _2289_/D _1177_/X VGND VGND VPWR VPWR _2289_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1309_ _1330_/A _2258_/Q VGND VGND VPWR VPWR _1310_/B sky130_fd_sc_hd__or2_1
XFILLER_8_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1591_ _1175_/X _1090_/A _1587_/X _2210_/Q _1588_/X VGND VGND VPWR VPWR _2210_/D
+ sky130_fd_sc_hd__o32a_1
X_1660_ _1860_/A _1651_/X _1658_/Y _1975_/A _1658_/A VGND VGND VPWR VPWR _1661_/A
+ sky130_fd_sc_hd__o32a_1
XFILLER_7_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2143_ _2224_/CLK _2143_/D _1774_/X VGND VGND VPWR VPWR _2143_/Q sky130_fd_sc_hd__dfstp_1
X_2212_ _2223_/CLK _2212_/D _1567_/X VGND VGND VPWR VPWR _2212_/Q sky130_fd_sc_hd__dfrtp_1
X_2074_ _1943_/X _2297_/Q _2180_/D VGND VGND VPWR VPWR _2074_/X sky130_fd_sc_hd__mux2_1
X_1927_ _2094_/X _1927_/B VGND VGND VPWR VPWR _2175_/D sky130_fd_sc_hd__nor2_1
X_1858_ _2141_/Q _1961_/B _1808_/B _1814_/B VGND VGND VPWR VPWR _1858_/Y sky130_fd_sc_hd__a31oi_1
XFILLER_39_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1789_ _1792_/A VGND VGND VPWR VPWR _1789_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_55_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1712_ _1112_/Y _1113_/A _1696_/X _1711_/Y _1684_/A VGND VGND VPWR VPWR _1713_/A
+ sky130_fd_sc_hd__o32a_1
X_1643_ _1670_/A VGND VGND VPWR VPWR _1643_/X sky130_fd_sc_hd__clkbuf_1
XANTENNA_1 _1798_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1574_ _2137_/Q _2150_/Q _1574_/C VGND VGND VPWR VPWR _1580_/A sky130_fd_sc_hd__and3_1
X_2057_ _2017_/Y _2293_/Q _2060_/S VGND VGND VPWR VPWR _2116_/D sky130_fd_sc_hd__mux2_2
XFILLER_25_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2126_ _2287_/CLK _2126_/D _1795_/X VGND VGND VPWR VPWR _2126_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_41_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1290_ _2180_/Q VGND VGND VPWR VPWR _1357_/A sky130_fd_sc_hd__inv_2
XFILLER_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1626_ _2232_/Q _2207_/Q _1472_/Y _1625_/Y VGND VGND VPWR VPWR _1626_/X sky130_fd_sc_hd__o22a_1
XFILLER_39_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1557_ _2214_/Q VGND VGND VPWR VPWR _1557_/Y sky130_fd_sc_hd__inv_2
X_1488_ _2154_/Q _2189_/Q VGND VGND VPWR VPWR _1488_/Y sky130_fd_sc_hd__nor2_2
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2109_ _2108_/X _2196_/Q _2185_/Q VGND VGND VPWR VPWR _2109_/X sky130_fd_sc_hd__mux2_1
Xclkbuf_1_0__f_wb_clk_i clkbuf_0_wb_clk_i/X VGND VGND VPWR VPWR clkbuf_leaf_8_wb_clk_i/A
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_22_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_11_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2295_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_45_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1411_ _1391_/A _1378_/B _2247_/Q _1392_/X VGND VGND VPWR VPWR _2247_/D sky130_fd_sc_hd__a2bb2o_1
X_1342_ _1365_/A VGND VGND VPWR VPWR _1342_/X sky130_fd_sc_hd__clkbuf_1
X_1273_ _1273_/A VGND VGND VPWR VPWR _1744_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_36_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1609_ _1573_/A _2188_/D _1664_/A _1580_/X VGND VGND VPWR VPWR _1610_/S sky130_fd_sc_hd__a31o_1
XFILLER_42_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1891_ _2312_/Q VGND VGND VPWR VPWR _1901_/A sky130_fd_sc_hd__buf_1
X_1960_ _1613_/X _1960_/B _1960_/C _1960_/D VGND VGND VPWR VPWR _2083_/S sky130_fd_sc_hd__and4b_1
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1256_ _2066_/X _1243_/A _2269_/Q _1244_/A VGND VGND VPWR VPWR _2269_/D sky130_fd_sc_hd__a22o_1
X_1325_ _2246_/Q _2245_/Q _1374_/C _1374_/D VGND VGND VPWR VPWR _1338_/B sky130_fd_sc_hd__or4_4
XFILLER_24_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1187_ _1187_/A VGND VGND VPWR VPWR _1187_/X sky130_fd_sc_hd__clkbuf_2
XPHY_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2090_ _1923_/Y _1922_/Y _2095_/S VGND VGND VPWR VPWR _2090_/X sky130_fd_sc_hd__mux2_1
X_1110_ _1110_/A VGND VGND VPWR VPWR _2307_/D sky130_fd_sc_hd__inv_2
XFILLER_0_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1943_ _2277_/Q _1942_/B _1944_/B VGND VGND VPWR VPWR _1943_/X sky130_fd_sc_hd__a21bo_1
X_1874_ _2226_/Q _2225_/Q _1930_/A VGND VGND VPWR VPWR _2126_/D sky130_fd_sc_hd__o21a_1
X_1239_ _2073_/X _1230_/X _2276_/Q _1231_/X VGND VGND VPWR VPWR _2276_/D sky130_fd_sc_hd__a22o_1
X_2288_ _2312_/CLK _2288_/D _1179_/X VGND VGND VPWR VPWR _2288_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_29_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1308_ _2256_/Q _2255_/Q _1313_/C VGND VGND VPWR VPWR _1355_/A sky130_fd_sc_hd__or3_1
XFILLER_20_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1590_ _1594_/A VGND VGND VPWR VPWR _1590_/X sky130_fd_sc_hd__clkbuf_1
X_2073_ _1941_/X _2296_/Q _2180_/D VGND VGND VPWR VPWR _2073_/X sky130_fd_sc_hd__mux2_1
X_2211_ _2234_/CLK _2211_/D _1583_/X VGND VGND VPWR VPWR _2211_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_38_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2142_ _2142_/CLK _2142_/D _1776_/X VGND VGND VPWR VPWR _2142_/Q sky130_fd_sc_hd__dfrtp_1
X_1926_ _2175_/Q _1267_/B _2095_/S VGND VGND VPWR VPWR _1926_/Y sky130_fd_sc_hd__a21oi_1
X_1788_ _1792_/A VGND VGND VPWR VPWR _1788_/X sky130_fd_sc_hd__clkbuf_1
X_1857_ _2128_/Q _1848_/A _1856_/Y VGND VGND VPWR VPWR _2128_/D sky130_fd_sc_hd__a21o_1
XFILLER_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_2 _1854_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1711_ _2191_/Q VGND VGND VPWR VPWR _1711_/Y sky130_fd_sc_hd__inv_2
X_1642_ _1187_/X _1575_/Y _2201_/Q _2134_/Q _2047_/C VGND VGND VPWR VPWR _2201_/D
+ sky130_fd_sc_hd__o221a_1
X_1573_ _1573_/A _1576_/A VGND VGND VPWR VPWR _1574_/C sky130_fd_sc_hd__nor2_1
X_2056_ _2011_/Y _2292_/Q _2060_/S VGND VGND VPWR VPWR _2115_/D sky130_fd_sc_hd__mux2_2
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2125_ _2223_/CLK _2125_/D _1796_/X VGND VGND VPWR VPWR _2125_/Q sky130_fd_sc_hd__dfrtp_1
X_1909_ _2312_/Q _1909_/B _2087_/X VGND VGND VPWR VPWR _2170_/D sky130_fd_sc_hd__and3_1
XFILLER_1_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1625_ _2207_/Q VGND VGND VPWR VPWR _1625_/Y sky130_fd_sc_hd__inv_2
X_1556_ _1562_/A VGND VGND VPWR VPWR _1556_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_39_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1487_ _1487_/A VGND VGND VPWR VPWR _1487_/X sky130_fd_sc_hd__buf_1
XFILLER_54_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2039_ _2042_/A _2039_/B VGND VGND VPWR VPWR _2181_/D sky130_fd_sc_hd__nor2_1
X_2108_ _2235_/Q _2221_/Q _2186_/Q VGND VGND VPWR VPWR _2108_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1410_ _1418_/A VGND VGND VPWR VPWR _1410_/X sky130_fd_sc_hd__clkbuf_1
X_1272_ _2267_/Q _2095_/S _2268_/Q _1270_/X _2042_/B VGND VGND VPWR VPWR _2268_/D
+ sky130_fd_sc_hd__a221o_1
XFILLER_36_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1341_ _1357_/B _1343_/A _2261_/Q _1340_/Y VGND VGND VPWR VPWR _2261_/D sky130_fd_sc_hd__o31a_1
XFILLER_51_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1539_ _1539_/A VGND VGND VPWR VPWR _1539_/X sky130_fd_sc_hd__clkbuf_1
X_1608_ _1608_/A VGND VGND VPWR VPWR _2188_/D sky130_fd_sc_hd__buf_1
XFILLER_47_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1890_ _2163_/Q _2162_/Q _1260_/B VGND VGND VPWR VPWR _1890_/X sky130_fd_sc_hd__a21bo_1
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1255_ _1257_/A VGND VGND VPWR VPWR _1255_/X sky130_fd_sc_hd__clkbuf_1
X_1324_ _1324_/A _1324_/B VGND VGND VPWR VPWR _1374_/D sky130_fd_sc_hd__or2_2
X_1186_ _2287_/Q VGND VGND VPWR VPWR _1187_/A sky130_fd_sc_hd__inv_2
XFILLER_48_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1942_ _2277_/Q _1942_/B VGND VGND VPWR VPWR _1944_/B sky130_fd_sc_hd__or2_1
XFILLER_0_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1873_ _1885_/B VGND VGND VPWR VPWR _1930_/A sky130_fd_sc_hd__buf_2
X_1238_ _1246_/A VGND VGND VPWR VPWR _1238_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_56_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1169_ _1248_/A VGND VGND VPWR VPWR _1179_/A sky130_fd_sc_hd__buf_1
X_1307_ _2180_/Q _1882_/C VGND VGND VPWR VPWR _1343_/A sky130_fd_sc_hd__and2_2
X_2287_ _2287_/CLK _2287_/D _1185_/X VGND VGND VPWR VPWR _2287_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_20_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2210_ _2220_/CLK _2210_/D _1590_/X VGND VGND VPWR VPWR _2210_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_53_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2072_ _1940_/X _2295_/Q _2180_/D VGND VGND VPWR VPWR _2072_/X sky130_fd_sc_hd__mux2_1
X_2141_ _2142_/CLK _2141_/D _1777_/X VGND VGND VPWR VPWR _2141_/Q sky130_fd_sc_hd__dfrtp_4
X_1925_ _2304_/Q VGND VGND VPWR VPWR _1925_/Y sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_6_wb_clk_i clkbuf_leaf_8_wb_clk_i/A VGND VGND VPWR VPWR _2282_/CLK sky130_fd_sc_hd__clkbuf_16
X_1856_ _1856_/A _1856_/B VGND VGND VPWR VPWR _1856_/Y sky130_fd_sc_hd__nand2_1
X_1787_ _1793_/A VGND VGND VPWR VPWR _1792_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_39_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_3 _1936_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1710_ _1719_/A VGND VGND VPWR VPWR _1710_/X sky130_fd_sc_hd__clkbuf_1
X_1641_ _1670_/A VGND VGND VPWR VPWR _1641_/X sky130_fd_sc_hd__clkbuf_1
X_1572_ _2122_/Q VGND VGND VPWR VPWR _1573_/A sky130_fd_sc_hd__inv_2
X_2124_ _2222_/CLK _2124_/D _1797_/X VGND VGND VPWR VPWR _2124_/Q sky130_fd_sc_hd__dfrtp_1
X_2055_ _2004_/Y _2291_/Q _2060_/S VGND VGND VPWR VPWR _2114_/D sky130_fd_sc_hd__mux2_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1908_ _2170_/Q _1912_/C _1907_/Y VGND VGND VPWR VPWR _1908_/X sky130_fd_sc_hd__a21o_1
XFILLER_41_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1839_ _2146_/Q _1799_/S _1838_/X VGND VGND VPWR VPWR _1840_/B sky130_fd_sc_hd__a21oi_1
XFILLER_9_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1624_ _2208_/Q VGND VGND VPWR VPWR _1624_/Y sky130_fd_sc_hd__inv_2
X_1555_ _1886_/B _1554_/A _1553_/X _2215_/Q _1554_/Y VGND VGND VPWR VPWR _2215_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_39_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2107_ _2106_/X _2195_/Q _2185_/Q VGND VGND VPWR VPWR _2107_/X sky130_fd_sc_hd__mux2_1
X_1486_ _1664_/A _1460_/A _1886_/C _1463_/A VGND VGND VPWR VPWR _2229_/D sky130_fd_sc_hd__o22ai_1
XFILLER_52_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2038_ _2037_/Y _2121_/Q _1215_/A VGND VGND VPWR VPWR _2039_/B sky130_fd_sc_hd__o21a_1
XFILLER_45_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1340_ _1357_/B _1343_/A _1316_/X _1332_/X _1339_/X VGND VGND VPWR VPWR _1340_/Y
+ sky130_fd_sc_hd__o2111ai_4
X_1271_ _1271_/A VGND VGND VPWR VPWR _2042_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_3_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_20_wb_clk_i clkbuf_leaf_9_wb_clk_i/A VGND VGND VPWR VPWR _2142_/CLK sky130_fd_sc_hd__clkbuf_16
X_1469_ _2233_/Q VGND VGND VPWR VPWR _1469_/Y sky130_fd_sc_hd__inv_2
X_1538_ _1523_/X _1527_/X _2103_/X _2219_/Q _1528_/X VGND VGND VPWR VPWR _2219_/D
+ sky130_fd_sc_hd__a32o_1
X_1607_ _2137_/Q _2150_/Q _1620_/A VGND VGND VPWR VPWR _1608_/A sky130_fd_sc_hd__and3_1
XFILLER_27_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1323_ _2243_/Q VGND VGND VPWR VPWR _1326_/C sky130_fd_sc_hd__inv_2
X_1254_ _2067_/X _1243_/X _2270_/Q _1244_/X VGND VGND VPWR VPWR _2270_/D sky130_fd_sc_hd__a22o_1
X_1185_ _1220_/A VGND VGND VPWR VPWR _1185_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_32_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1941_ _2276_/Q _1210_/B _1942_/B VGND VGND VPWR VPWR _1941_/X sky130_fd_sc_hd__a21bo_1
XFILLER_9_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1872_ _2154_/Q _2189_/Q _1871_/X _1191_/Y _1931_/A VGND VGND VPWR VPWR _2127_/D
+ sky130_fd_sc_hd__o311a_1
XFILLER_56_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2286_ _2286_/CLK _2286_/D _1190_/X VGND VGND VPWR VPWR _2286_/Q sky130_fd_sc_hd__dfrtp_1
X_1306_ _1356_/A _1306_/B VGND VGND VPWR VPWR _1882_/C sky130_fd_sc_hd__or2_1
XFILLER_52_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1237_ _2074_/X _1230_/X _2277_/Q _1231_/X VGND VGND VPWR VPWR _2277_/D sky130_fd_sc_hd__a22o_1
XFILLER_44_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1099_ _1099_/A VGND VGND VPWR VPWR _1099_/X sky130_fd_sc_hd__clkbuf_1
X_1168_ _1793_/A VGND VGND VPWR VPWR _1248_/A sky130_fd_sc_hd__buf_2
XFILLER_12_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2140_ _2142_/CLK _2140_/D _1778_/X VGND VGND VPWR VPWR _2140_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_22_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2071_ _1939_/Y _2294_/Q _2180_/D VGND VGND VPWR VPWR _2071_/X sky130_fd_sc_hd__mux2_1
XFILLER_46_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1924_ _2090_/X _1927_/B VGND VGND VPWR VPWR _2174_/D sky130_fd_sc_hd__nor2_1
X_1855_ _1842_/C _1851_/B _1804_/A _1396_/Y _1854_/Y VGND VGND VPWR VPWR _1856_/B
+ sky130_fd_sc_hd__o32a_1
X_1786_ _1786_/A VGND VGND VPWR VPWR _1786_/X sky130_fd_sc_hd__clkbuf_1
X_2269_ _2307_/CLK _2269_/D _1255_/X VGND VGND VPWR VPWR _2269_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_25_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_4 _2113_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1571_ _1571_/A _1819_/A VGND VGND VPWR VPWR _1579_/B sky130_fd_sc_hd__nor2_2
X_1640_ _2202_/Q _2132_/Q _2047_/C _1639_/X VGND VGND VPWR VPWR _2202_/D sky130_fd_sc_hd__o211a_1
X_2123_ _2137_/CLK _2123_/D _1798_/X VGND VGND VPWR VPWR _2123_/Q sky130_fd_sc_hd__dfrtp_1
X_2054_ _1997_/Y _2290_/Q _2060_/S VGND VGND VPWR VPWR _2113_/D sky130_fd_sc_hd__mux2_2
XFILLER_34_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1907_ _2170_/Q _1912_/C VGND VGND VPWR VPWR _1907_/Y sky130_fd_sc_hd__nor2_1
X_1838_ _2158_/Q _1829_/Y _2145_/Q VGND VGND VPWR VPWR _1838_/X sky130_fd_sc_hd__o21a_1
XFILLER_1_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1769_ _1769_/A VGND VGND VPWR VPWR _1774_/A sky130_fd_sc_hd__buf_1
XFILLER_40_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput30 _2118_/Q VGND VGND VPWR VPWR wb_dat_o[6] sky130_fd_sc_hd__clkbuf_2
XFILLER_48_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1485_ _2159_/Q VGND VGND VPWR VPWR _1886_/C sky130_fd_sc_hd__inv_2
X_1623_ _1809_/B VGND VGND VPWR VPWR _1960_/B sky130_fd_sc_hd__buf_1
X_1554_ _1554_/A VGND VGND VPWR VPWR _1554_/Y sky130_fd_sc_hd__inv_2
.ends
